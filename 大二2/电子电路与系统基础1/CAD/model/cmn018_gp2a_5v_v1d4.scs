+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     7: type=p 
+ lmin=6e-007-dxlp_5-dxlmisp_5                        lmax=1.2e-006-dxlp_5-dxlmisp_5
+ wmin=1.2e-006-dxwp_5-dxwmisp_5                      wmax=1e-005-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.73338006+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=3.2376215e-009+dlvthp_5                       wvth0=8.680197e-008+dwvthp_5
+ pvth0=1.6917286e-014+dpvthp_5                       k1=0.97
+ k2=0.033023784+dk2p_5+dk2misp_5                     lk2=1.6207693e-009+dlk2p_5
+ wk2=1.3982444e-009+dwk2p_5                          pk2=6.0132539e-016+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00087648244         lcit=7.2645812e-011       wcit=-8.7430093e-011
+ pcit=4.6268767e-017       voff=-0.17005665          lvoff=-1.4978365e-009
+ wvoff=8.7108268e-009      pvoff=2.0155134e-015      nfactor=0.5
+ eta0=0.004                etab=-0.065014738         wetab=7.8852524e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=(0.015172993+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(-4.5056006e-010+dlu0p_5)*fu0misp_5
+ wu0=(-4.9319315e-010+dwu0p_5)*fu0misp_5             pu0=(-5.5159399e-016+dpu0p_5)*fu0misp_5
+ ua=2.3582765e-009         lua=1.0609733e-016        wua=4.7767817e-016
+ pua=-8.2153124e-023       ub=-4.8786089e-020        lub=-4.4042657e-026
+ wub=-8.9721138e-025       pub=5.2039011e-032        uc=-5.6176527e-011
+ luc=7.900713e-018         wuc=-4.1876563e-017       puc=6.1037679e-024
+ vsat=80502.795            lvsat=-0.0047350183+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-0.003231178        pvsat=4.8025809e-009+dpvsatp_5
+ a0=1.1105985              la0=-2.311863e-007+dla0p_5
+ wa0=2.0227345e-007        pa0=-3.7776398e-014       ags=0.16722155+dagsp_5
+ lags=-3.0164116e-008      wags=-4.1756698e-009+dwagsp_5
+ pags=2.2421163e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.0023568153
+ lketa=-3.1528004e-009     wketa=4.3475029e-009      pketa=-6.2633659e-015
+ dwg=0                     dwb=0                     pclm=0.18489458+dpclmp_5
+ lpclm=1.0317982e-007      wpclm=2.6027756e-007+dwpclmp_5
+ ppclm=-1.2484758e-013     pdiblc1=0                 pdiblc2=0.00057881854+dpdiblc2p_5
+ lpdiblc2=5.681101e-010    wpdiblc2=-1.6737428e-009  ppdiblc2=8.165228e-016
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=60.902075          lalpha1=-1.8437698e-005
+ walpha1=2.2187582e-005    palpha1=-1.1126955e-011   beta0=45.596656+dbeta0p_5
+ lbeta0=-3.7171826e-006    wbeta0=3.2830489e-006     pbeta0=-1.9073665e-012+dpbeta0p_5
+ agidl=8.7334469e-012      lagidl=9.0539451e-019     wagidl=-2.5467709e-019
+ pagidl=-1.5071514e-025    bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.000925054         ltvoff=4.96893e-010       wtvoff=1.48832e-009
+ ptvoff=-7.32099e-016      kt1=-0.38666979           lkt1=-9.6757057e-009
+ wkt1=2.1206214e-008       pkt1=-1.1397651e-014      kt1l=0
+ kt2=-0.051445371          lkt2=4.2385359e-009       wkt2=-1.1726977e-008
+ pkt2=7.2541559e-016       ute=-1.0710499            lute=-5.5940449e-008
+ wute=8.0693196e-008       pute=-9.7418206e-014      ua1=1.8170269e-009
+ lua1=-4.3318512e-016      wua1=-1.3441018e-015      pua1=-2.1934714e-022
+ ub1=-5.0323868e-018       lub1=6.4374163e-025       wub1=3.4884675e-024
+ pub1=-7.2665972e-031      uc1=-5.7448676e-011       luc1=2.1254747e-017
+ wuc1=1.4401663e-016       puc1=-3.2583364e-023      prt=0
+ at=40295.472              lat=-0.032631821          wat=0.0019469237
+ pat=-6.3060929e-009+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     8: type=p 
+ lmin=5e-07                lmax=6e-007-dxlp_5-dxlmisp_5
+ wmin=1.2e-006-dxwp_5-dxwmisp_5                      wmax=1e-005-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.69639476+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-1.222223e-008+dlvthp_5                       wvth0=1.0397571e-007+dwvthp_5
+ pvth0=9.7386611e-015+dpvthp_5                       k1=0.97
+ k2=0.042619626+dk2p_5+dk2misp_5                     lk2=-2.3902928e-009+dlk2p_5
+ wk2=1.2071443e-008+dwk2p_5                          pk2=-3.8600716e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00085535359         lcit=8.1477672e-011       wcit=5.6613312e-010
+ pcit=-2.2692065e-016      voff=-0.22952122          lvoff=2.3358355e-008
+ wvoff=7.8219421e-008      pvoff=-2.7039079e-014     nfactor=0.5
+ eta0=0.004                etab=-0.065014738         wetab=7.8852524e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=(0.014152714+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(-2.4083479e-011+dlu0p_5)*fu0misp_5
+ wu0=(-7.6152636e-010+dwu0p_5)*fu0misp_5             pu0=(-4.394307e-016+dpu0p_5)*fu0misp_5
+ ua=2.1532872e-009         lua=1.9178284e-016        wua=6.9949039e-016
+ pua=-1.7487063e-022       ub=-2.4873725e-019        lub=3.9536928e-026
+ wub=-1.011579e-024        pub=9.9844691e-032        uc=-2.1187839e-011
+ luc=-6.7245587e-018       wuc=2.6810684e-018        puc=-1.2521322e-023
+ vsat=67503.83             lvsat=0.00069854885+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=0.024986657         pvsat=-6.992474e-009+dpvsatp_5
+ a0=0.98363314             la0=-1.7811477e-007+dla0p_5
+ wa0=5.582539e-007         pa0=-1.8657623e-013       ags=0.079344922+dagsp_5
+ lags=6.5683148e-009       wags=2.0675733e-007+dwagsp_5
+ pags=-6.5748832e-014      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.022717129
+ lketa=5.3578109e-009      wketa=-8.3405187e-009     pketa=-9.5977286e-016
+ dwg=0                     dwb=0                     pclm=0.35179502+dpclmp_5
+ lpclm=3.3415432e-008      wpclm=5.832802e-008+dwpclmp_5
+ ppclm=-4.0432673e-014     pdiblc1=0                 pdiblc2=-0.0086259337+dpdiblc2p_5
+ lpdiblc2=4.4156965e-009   wpdiblc2=6.3346486e-011   ppdiblc2=9.0419495e-017
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=37.537878          lalpha1=-8.6714633e-006
+ walpha1=-6.1389078e-006   palpha1=7.1351776e-013    beta0=45.720368+dbeta0p_5
+ lbeta0=-3.7688939e-006    wbeta0=1.1272511e-006     pbeta0=-1.006243e-012+dpbeta0p_5
+ agidl=-2.4652597e-011     lagidl=1.4860761e-017     wagidl=7.2756365e-018
+ pagidl=-3.2983862e-024    bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00348618          ltvoff=-5.7366e-010       wtvoff=3.91326e-010
+ ptvoff=-2.73556e-016      kt1=-0.34536277           lkt1=-2.6942039e-008
+ wkt1=-4.48929e-008        pkt1=1.6231779e-014       kt1l=0
+ kt2=-0.034378684          lkt2=-2.8953397e-009      wkt2=-3.4650803e-008
+ pkt2=1.0307575e-014       ute=-1.1643019            lute=-1.6961102e-008
+ wute=-2.7841864e-007      pute=5.2690542e-014       ua1=3.9247732e-009
+ lua1=-1.3142231e-015      wua1=-6.7933188e-015      pua1=2.0584255e-021
+ ub1=-1.031542e-017        lub1=2.8520495e-024       wub1=1.1804126e-023
+ pub1=-4.2026051e-030      uc1=-2.647524e-010        luc1=1.079077e-016
+ wuc1=4.092128e-016        puc1=-1.4343536e-022      prt=0
+ at=-41941.756             lat=0.0017433404          wat=-0.014896085
+ pat=7.3428478e-010+dpatp_5                          fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     9: type=p 
+ lmin=1e-005-dxlp_5-dxlmisp_5                        lmax=900.01e-6
+ wmin=5e-007-dxwp_5-dxwmisp_5                        wmax=1.2e-006-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.66249378+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ wvth0=2.0891039e-009+dwvthp_5                       k1=0.97
+ k2=0.041827672+dk2p_5+dk2misp_5                     wk2=-6.4689064e-009+dwk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00067803157         wcit=-1.0323201e-011      voff=-0.16435748
+ wvoff=1.2795516e-009      nfactor=0.5               eta0=0.004
+ etab=-0.036925729         wetab=-2.6102448e-008     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=(0.015851557+du0p_5)*fu0misp_5                   ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         wu0=(-1.9209441e-009+dwu0p_5)*fu0misp_5
+ ua=2.7971729e-009         wua=-5.5547816e-016       ub=-4.2843271e-019
+ wub=9.3266878e-026        uc=-7.6455671e-011        wuc=-1.4532108e-017
+ vsat=77945.092            wvsat=-0.00099199707      a0=1.2540152
+ kvsat=-2.550000e-01       wa0=-5.304775e-008        ags=0.11212959+dagsp_5
+ wags=-8.8607187e-009+dwagsp_5                       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.0099246886         wketa=2.0997268e-009      dwg=0
+ dwb=0                     pclm=0.29879+dpclmp_5     wpclm=6.171e-010+dwpclmp_5
+ pdiblc1=0                 pdiblc2=0.00034439999+dpdiblc2p_5
+ wpdiblc2=-1.0563299e-010  pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=107.91571
+ walpha1=8.1897986e-005    beta0=47.37+dbeta0p_5     wbeta0=2.34498e-006
+ agidl=-1.9584243e-011     wagidl=3.0198869e-017     bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5
+ cgdo=cgop_5               cgbo=0                    cgdl=cglp_5
+ cgsl=cglp_5               clc=1e-007                cle=0.6
+ cf=cfp_5                  ckappas=0.6               ckappad=0.6
+ acde=1                    moin=25                   noff=2
+ voffcv=-0.02              tvoff=0.00232204          ltvoff=0
+ wtvoff=3.97589e-011       ptvoff=0                  kt1=-0.37354181
+ wkt1=8.118215e-010        kt1l=0                    kt2=-0.054391374
+ wkt2=-8.9950863e-009      ute=-1.2260829            wute=-7.3346743e-008
+ ua1=-2.2534514e-010       wua1=-3.5998088e-016      ub1=-1.1897143e-018
+ wub1=4.2315429e-025       uc1=8.3441912e-011        wuc1=4.3646249e-018
+ prt=0                     at=70000                  fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lvth0=0+dlvthp_5
+ pvth0=0+dpvthp_5          lu0=(0+dlu0p_5)*fu0misp_5 pu0=(0+dpu0p_5)*fu0misp_5
+ lk2=0+dlk2p_5             pk2=0+dpk2p_5             lvsat=0+dlvsatp_5
+ pvsat=0+dpvsatp_5         pbeta0=0+dpbeta0p_5       la0=0+dla0p_5
+ pat=0+dpatp_5             saref=1.000000e-05        sbref=1.000000e-05
+ llodvth=1.000000e+00      wlodvth=1.000000e+00      wlod=1.700000e-06
+ steta0=0.000000e+00       lodeta0=1.000000e+00      stk2=6.000000e-09
+ lodk2=1.000000e+00        llodku0=1.000000e+00      wlodku0=1.000000e+00
+ wpemod=1.000000e+00       scref=1.000000e-06        wec=0.000000e+00
+ web=0.000000e+00          kvth0we=-8.500000e-03     pkvth0we=0.000000e+00
+ wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09     ku0we=-2.500000e-03
+ pku0we=0.000000e+00       wku0we=1.000000e-09       lku0we=0.000000e+00
+ k2we=-8.000000e-04        pk2we=0.000000e+00        lk2we=0.000000e+00
+ wk2we=0.000000e+00        rshg=8.41                 minr=1e-3
 
     10: type=p 
+ lmin=1.2e-006-dxlp_5-dxlmisp_5                      lmax=1e-005-dxlp_5-dxlmisp_5
+ wmin=5e-007-dxwp_5-dxwmisp_5                        wmax=1.2e-006-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.66220918+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-2.7942352e-009+dlvthp_5                      wvth0=-5.0029013e-010+dwvthp_5
+ pvth0=2.542267e-014+dpvthp_5                        k1=0.97
+ k2=0.041763423+dk2p_5+dk2misp_5                     lk2=6.3079327e-010+dlk2p_5
+ wk2=-6.3601158e-009+dwk2p_5                         pk2=-1.0681061e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00064347909         lcit=3.3923622e-010       wcit=-2.6196128e-012
+ pcit=-7.5633833e-017      voff=-0.16323479          lvoff=-1.1022545e-008
+ wvoff=-1.6390547e-010     pvoff=1.4171861e-014      nfactor=0.5
+ eta0=0.004                etab=-0.036925729         wetab=-2.6102448e-008
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=(0.015927826+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(-7.4880927e-010+dlu0p_5)*fu0misp_5
+ wu0=(-1.9587794e-009+dwu0p_5)*fu0misp_5             pu0=(3.7146641e-016+dpu0p_5)*fu0misp_5
+ ua=2.7472564e-009         lua=4.9008003e-016        wua=-5.5841489e-016
+ pua=2.8832882e-023        ub=-3.5584932e-019        lub=-7.1262375e-025
+ wub=6.7022604e-026        pub=2.5766629e-031        uc=-7.8216048e-011
+ luc=1.7283376e-017        wuc=-1.3857327e-017       puc=-6.6249958e-024
+ vsat=78028.807            lvsat=-0.00082191593+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-0.0010869572       pvsat=9.3231861e-010+dpvsatp_5
+ a0=1.2954145              la0=-4.0645855e-007+dla0p_5
+ wa0=-7.6521313e-008       pa0=2.3046345e-013        ags=0.10958885+dagsp_5
+ lags=2.4945027e-008       wags=-1.2440184e-008+dwagsp_5
+ pags=3.5143188e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=0.011809559
+ lketa=-1.8505662e-008     wketa=2.423366e-009       pketa=-3.1774896e-015
+ dwg=0                     dwb=0                     pclm=0.28371054+dpclmp_5
+ lpclm=1.4805009e-007      wpclm=4.7677587e-009+dwpclmp_5
+ ppclm=-4.0751167e-014     pdiblc1=0                 pdiblc2=0.00030938286+dpdiblc2p_5
+ lpdiblc2=3.4379823e-010   wpdiblc2=-8.5575028e-011  ppdiblc2=-1.9692911e-016
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=117.89678          lalpha1=-9.7994148e-005
+ walpha1=8.7108643e-005    palpha1=-5.1158234e-011   beta0=48.24452+dbeta0p_5
+ lbeta0=-8.5860358e-006    wbeta0=2.154376e-006      pbeta0=1.8713497e-012+dpbeta0p_5
+ agidl=-2.0676908e-011     lagidl=1.0727779e-017     wagidl=3.0972781e-017
+ pagidl=-7.5982663e-024    bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00241638          ltvoff=-9.26264e-010      wtvoff=-3.15551e-011
+ ptvoff=7.0016e-016        kt1=-0.37156939           lkt1=-1.9365164e-008
+ wkt1=5.2912585e-010       pkt1=2.7755059e-015       kt1l=0
+ kt2=-0.054794214          lkt2=3.9550838e-009       wkt2=-9.2692187e-009
+ pkt2=2.6914318e-015       ute=-1.2433986            lute=1.7000604e-007
+ wute=-7.3152978e-008      pute=-1.9023886e-015      ua1=-2.5391359e-010
+ lua1=2.8048505e-016       wua1=-4.1296042e-016      pua1=5.201531e-022
+ ub1=-1.1336784e-018       lub1=-5.5016005e-025      wub1=5.3268847e-025
+ pub1=-1.0754066e-030      uc1=8.5267923e-011        luc1=-1.7927774e-017
+ wuc1=6.5012412e-018       puc1=-2.0977299e-023      prt=0
+ at=76445.946              lat=-0.063286294          wat=0.0013365503
+ pat=-1.3122251e-008+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     11: type=p 
+ lmin=6e-007-dxlp_5-dxlmisp_5                        lmax=1.2e-006-dxlp_5-dxlmisp_5
+ wmin=5e-007-dxwp_5-dxwmisp_5                        wmax=1.2e-006-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.66070827+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-4.3221625e-009+dlvthp_5                      wvth0=-1.1308937e-009+dwvthp_5
+ pvth0=2.6064625e-014+dpvthp_5                       k1=0.97
+ k2=0.037832258+dk2p_5+dk2misp_5                     lk2=4.6327196e-009+dlk2p_5
+ wk2=-4.4200094e-009+dwk2p_5                         pk2=-3.0431344e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00083765343         lcit=1.4156674e-010       wcit=-4.0446993e-011
+ pcit=-3.712556e-017       voff=-0.15683263          lvoff=-1.7539949e-008
+ wvoff=-7.2902399e-009     pvoff=2.1426469e-014      nfactor=0.5
+ eta0=0.004                etab=-0.036925729         wetab=-2.6102448e-008
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=(0.016472021+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(-1.3027997e-009+dlu0p_5)*fu0misp_5
+ wu0=(-2.0650167e-009+dwu0p_5)*fu0misp_5             pu0=(4.7961595e-016+dpu0p_5)*fu0misp_5
+ ua=3.437413e-009          lua=-2.1249938e-016       wua=-8.2807698e-016
+ pua=3.0334889e-022        ub=-1.2907724e-018        lub=2.3912799e-025
+ wub=6.0559211e-025        pub=-2.9059748e-031       uc=-9.1761656e-011
+ luc=3.1072806e-017        wuc=1.1814438e-018        puc=-2.1934465e-023
+ vsat=79769.669            lvsat=-0.002594113+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-0.0023440955       pvsat=2.2120854e-009+dpvsatp_5
+ a0=1.341711               la0=-4.5358832e-007+dla0p_5
+ wa0=-7.7372586e-008       pa0=2.3133004e-013        ags=0.19337448+dagsp_5
+ lags=-6.0348748e-008      wags=-3.5820714e-008+dwagsp_5
+ pags=5.8944568e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=0.0063616752
+ lketa=-1.2959715e-008     wketa=-6.2018706e-009     pketa=5.6030012e-015
+ dwg=0                     dwb=0                     pclm=0.4955391+dpclmp_5
+ lpclm=-6.7591376e-008     wpclm=-1.1560231e-007+dwpclmp_5
+ ppclm=8.1785565e-014      pdiblc1=0                 pdiblc2=-0.0013027447+dpdiblc2p_5
+ lpdiblc2=1.9849441e-009   wpdiblc2=6.0294871e-010   ppdiblc2=-8.9784628e-016
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=45.582055          lalpha1=-2.4377753e-005
+ walpha1=4.0724806e-005    palpha1=-3.9394881e-012   beta0=47.433874+dbeta0p_5
+ lbeta0=-7.7607979e-006    wbeta0=1.0600162e-006     pbeta0=2.985408e-012+dpbeta0p_5
+ agidl=-9.6020361e-012     lagidl=-5.4644023e-019    wagidl=2.1931257e-017
+ pagidl=1.6060049e-024     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00221535          ltvoff=-7.21607e-010      wtvoff=-7.29357e-011
+ ptvoff=7.42286e-016       kt1=-0.37513789           lkt1=-1.5732436e-008
+ wkt1=7.2526162e-009       pkt1=-4.0690073e-015      kt1l=0
+ kt2=-0.055181009          lkt2=4.3488418e-009       wkt2=-7.2068549e-009
+ pkt2=5.9194545e-016       ute=-0.9124255            lute=-1.6692459e-007
+ wute=-1.1124236e-007      pute=3.6872602e-014       ua1=4.690294e-010
+ lua1=-4.5547091e-016      wua1=2.8697518e-016       pua1=-1.9238133e-022
+ ub1=-9.3562626e-019       lub1=-7.5177717e-025      wub1=-1.4686128e-024
+ pub1=9.6191803e-031       uc1=1.0368476e-010        luc1=-3.6676116e-017
+ wuc1=-5.0954829e-017      puc1=3.751298e-023        prt=0
+ at=49027.864              lat=-0.035374688          wat=-0.0086192712
+ pat=-2.9872243e-009+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     12: type=p 
+ lmin=5e-07                lmax=6e-007-dxlp_5-dxlmisp_5
+ wmin=5e-007-dxwp_5-dxwmisp_5                        wmax=1.2e-006-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.60824653+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-2.6251167e-008+dlvthp_5                      wvth0=-2.6836445e-009+dwvthp_5
+ pvth0=2.6713675e-014+dpvthp_5                       k1=0.97
+ k2=0.054494556+dk2p_5+dk2misp_5                     lk2=-2.3321208e-009+dlk2p_5
+ wk2=-2.2972216e-009+dwk2p_5                         pk2=-3.9304597e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.0019219753          lcit=-3.1167981e-010      wcit=-7.2447919e-010
+ pcit=2.487999e-016        voff=-0.27053841          lvoff=2.9989068e-008
+ wvoff=1.2785022e-007      pvoff=-3.5062242e-014     nfactor=0.5
+ eta0=0.004                etab=-0.036925729         wetab=-2.6102448e-008
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=(0.014296286+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(-3.9334223e-010+dlu0p_5)*fu0misp_5
+ wu0=(-9.3524736e-010+dwu0p_5)*fu0misp_5             pu0=(7.3723884e-018+dpu0p_5)*fu0misp_5
+ ua=2.9612722e-009         lua=-1.3472551e-017       wua=-2.781715e-016
+ pua=7.3488395e-023        ub=-1.5053681e-018        lub=3.2882898e-025
+ wub=5.089443e-025         pub=-2.5019869e-031       uc=-7.0614526e-012
+ luc=-4.3318792e-018       wuc=-1.4411859e-017       puc=-1.5416464e-023
+ vsat=85666.646            lvsat=-0.0050590495+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=0.0030096496        pvsat=-2.578004e-011+dpvsatp_5
+ a0=0.31576077             la0=-2.4741144e-008+dla0p_5
+ wa0=1.3663795e-006        pa0=-3.7215832e-013       ags=0.0026607052+dagsp_5
+ lags=1.936961e-008        wags=2.9954523e-007+dwagsp_5
+ pags=-8.1238399e-014      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.024937442
+ lketa=1.2331549e-010      wketa=-5.6539407e-009     pketa=5.3739665e-015
+ dwg=0                     dwb=0                     pclm=0.3551254+dpclmp_5
+ lpclm=-8.8984476e-009     wpclm=5.429827e-008+dwpclmp_5
+ ppclm=1.0767122e-014      pdiblc1=0                 pdiblc2=-0.0048624848+dpdiblc2p_5
+ lpdiblc2=3.4729154e-009   wpdiblc2=-4.4904267e-009  ppdiblc2=1.2311846e-015
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=-64.563479         lalpha1=2.166308e-005
+ walpha1=0.00011740373     palpha1=-3.599128e-011    beta0=31.794471+dbeta0p_5
+ lbeta0=-1.2235274e-006    wbeta0=1.7977586e-005     pbeta0=-4.0861364e-012+dpbeta0p_5
+ agidl=-6.0226064e-011     lagidl=2.0614403e-017     wagidl=5.0319531e-017
+ pagidl=-1.0260294e-023    bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.000159353         ltvoff=1.37798e-010       wtvoff=4.41679e-009
+ ptvoff=-1.13442e-015      kt1=-0.39750811           lkt1=-6.3816843e-009
+ wkt1=1.8202959e-008       pkt1=-8.6462505e-015      kt1l=0
+ kt2=-0.053757626          lkt2=3.7538673e-009       wkt2=-1.1202284e-008
+ pkt2=2.2620347e-015       ute=-1.601204             lute=1.2098483e-007
+ wute=2.5023285e-007       pute=-1.1422403e-013      ua1=-3.2609486e-009
+ lua1=1.1036599e-015       wua1=1.9014047e-015       pua1=-8.6721287e-022
+ ub1=4.07848e-019          lub1=-1.3133494e-024      wub1=-1.1710279e-024
+ pub1=8.3752756e-031       uc1=1.0625486e-010        luc1=-3.7750416e-017
+ wuc1=-3.9705977e-017      puc1=3.281096e-023        prt=0
+ at=-19400.611             lat=-0.0067715849         wat=-0.042170871
+ pat=1.1037344e-008+dpatp_5                          fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     13: type=p 
+ lmin=1e-005-dxlp_5-dxlmisp_5                        lmax=900.01e-6
+ wmin=2.2e-07              wmax=5e-007-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.66212202+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ wvth0=1.8995051e-009+dwvthp_5                       k1=0.97
+ k2=0.046774013+dk2p_5+dk2misp_5                     wk2=-8.9915406e-009+dwk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00049508143         wcit=8.2981371e-011       voff=-0.16598187
+ wvoff=2.1079916e-009      nfactor=0.5               eta0=0.004
+ etab=-0.097371071         wetab=4.7246764e-009      ud=0
+ lud=0                     wud=0                     pud=0
+ u0=(0.0131315+du0p_5)*fu0misp_5                     wu0=(-5.33715e-010+dwu0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         ua=2.3283196e-009
+ wua=-3.1636298e-016       ub=-3.9613231e-019        wub=7.679367e-026
+ uc=-8.2809732e-011        wuc=-1.1291537e-017       vsat=76000
+ a0=1.2203421              wa0=-3.5874445e-008       kvsat=-2.550000e-01
+ ags=0.11509062+dagsp_5    wags=-1.0370842e-008+dwagsp_5
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.0093734571         wketa=2.3808549e-009
+ dwg=0                     dwb=0                     pclm=0.38214286+dpclmp_5
+ wpclm=-4.1892857e-008+dwpclmp_5                     pdiblc1=0
+ pdiblc2=8.724068e-005+dpdiblc2p_5                   wpdiblc2=2.5518256e-011
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=348.25729          walpha1=-4.0676216e-005
+ beta0=54.458571+dbeta0p_5 wbeta0=-1.2701914e-006    agidl=2.1645055e-011
+ wagidl=9.1719275e-018     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00125616          ltvoff=0                  wtvoff=5.83358e-010
+ ptvoff=0                  kt1=-0.4051201            wkt1=1.6916748e-008
+ kt1l=0                    kt2=-0.073438614          wkt2=7.1900618e-010
+ ute=-1.5631               wute=9.8532e-008          ua1=-1.8218157e-009
+ wua1=4.5421911e-016       ub1=-5.6818847e-019       wub1=1.0617612e-025
+ uc1=1.0185714e-010        wuc1=-5.0271429e-018      prt=0
+ at=70000                  fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.13                   noia=1.67e+41
+ noib=1.612e+24            noic=3.5e9                lintnoi=-1e-7
+ jss=1.94e-07              jsd=1.94e-07              jsws=7.03e-14
+ jswd=7.03e-14             jswgs=8.1e-14             jswgd=8.1e-14
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.4                   bvd=8.4                   xjbvs=1
+ xjbvd=1                   jtsswgs=5.2e-010          jtsswgd=5.2e-010
+ njtsswg=30                xtsswgs=0.48              xtsswgd=0.48
+ tnjtsswg=1.5              vtsswgs=19.9              vtsswgd=19.9
+ pbs=0.822                 pbd=0.822                 cjs=cjp_5
+ cjd=cjp_5                 mjs=0.367                 mjd=0.367
+ pbsws=0.767               pbswd=0.767               cjsws=cjswp_5
+ cjswd=cjswp_5             mjsws=0.275               mjswd=0.275
+ pbswgs=0.783              pbswgd=0.783              cjswgs=cjswgp_5
+ cjswgd=cjswgp_5           mjswgs=0.361              mjswgd=0.361
+ tpb=0.00165               tcj=0.000954              tpbsw=0.0016
+ tcjsw=0.0007              tpbswg=0.00187            tcjswg=0.00115
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthp_5          pvth0=0+dpvthp_5
+ lu0=(0+dlu0p_5)*fu0misp_5 pu0=(0+dpu0p_5)*fu0misp_5 lk2=0+dlk2p_5
+ pk2=0+dpk2p_5             lvsat=0+dlvsatp_5         pvsat=0+dpvsatp_5
+ pbeta0=0+dpbeta0p_5       la0=0+dla0p_5             pat=0+dpatp_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=1.700000e-06         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=6.000000e-09         lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        wec=0.000000e+00          web=0.000000e+00
+ kvth0we=-8.500000e-03     pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09
+ lkvth0we=1.000000e-09     ku0we=-2.500000e-03       pku0we=0.000000e+00
+ wku0we=1.000000e-09       lku0we=0.000000e+00       k2we=-8.000000e-04
+ pk2we=0.000000e+00        lk2we=0.000000e+00        wk2we=0.000000e+00
+ rshg=8.41                 minr=1e-3
 
     14: type=p 
+ lmin=1.2e-006-dxlp_5-dxlmisp_5                      lmax=1e-005-dxlp_5-dxlmisp_5
+ wmin=2.2e-07              wmax=5e-007-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.66479035+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=2.6197706e-008+dlvthp_5                       wvth0=8.161092e-010+dwvthp_5
+ pvth0=1.0636781e-014+dpvthp_5                       k1=0.97
+ k2=0.046617135+dk2p_5+dk2misp_5                     lk2=1.5402364e-009+dlk2p_5
+ wk2=-8.8355086e-009+dwk2p_5                         pk2=-1.5319221e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00045209576         lcit=4.2203334e-010       wcit=9.498589e-011
+ pcit=-1.1786036e-016      voff=-0.1649987           lvoff=-9.6528132e-009
+ wvoff=7.3568584e-010      pvoff=1.3473298e-014      nfactor=0.5
+ eta0=0.004                etab=-0.097371071         wetab=4.7246764e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=(0.013087815+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(4.2889997e-010+dlu0p_5)*fu0misp_5
+ wu0=(-5.1037366e-010+dwu0p_5)*fu0misp_5             pu0=(-2.291653e-016+dpu0p_5)*fu0misp_5
+ ua=2.2873169e-009         lua=4.0256436e-016        wua=-3.2384575e-016
+ pua=7.3465874e-023        ub=-3.7425258e-019        lub=-2.1481512e-025
+ wub=7.6408267e-026        pub=3.7838883e-033        uc=-8.4525724e-011
+ luc=1.6847613e-017        wuc=-1.0639392e-017       puc=-6.4027568e-024
+ vsat=76003.387            lvsat=-3.324998e-005+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-5.3992562e-005     pvsat=5.3009898e-010+dpvsatp_5
+ a0=1.2580608              la0=-3.7032308e-007+dla0p_5
+ wa0=-5.7470937e-008       pa0=2.1203436e-013        ags=0.10823775+dagsp_5
+ lags=6.7281399e-008       wags=-1.1751127e-008+dwagsp_5
+ pags=1.3551638e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=0.012424338
+ lketa=-2.9953551e-008     wketa=2.1098288e-009      pketa=2.660934e-015
+ dwg=0                     dwb=0                     pclm=0.3742517+dpclmp_5
+ lpclm=7.7475336e-008      wpclm=-4.1408233e-008+dwpclmp_5
+ ppclm=-4.7580403e-015     pdiblc1=0                 pdiblc2=8.5764659e-005+dpdiblc2p_5
+ lpdiblc2=1.4491577e-011   wpdiblc2=2.8470255e-011   ppdiblc2=-2.8982719e-017
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=378.26145          lalpha1=-0.00029458086
+ walpha1=-4.5677335e-005   palpha1=4.910099e-011     beta0=55.309333+dbeta0p_5
+ lbeta0=-8.3527742e-006    wbeta0=-1.4486785e-006    pbeta0=1.7523862e-012+dpbeta0p_5
+ agidl=2.2160064e-011      lagidl=-5.0563619e-018    wagidl=9.1259257e-018
+ pagidl=4.5164555e-025     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00119469          ltvoff=6.03567e-010       wtvoff=5.91512e-010
+ ptvoff=-8.00534e-017      kt1=-0.40598976           lkt1=8.5383829e-009
+ wkt1=1.8083514e-008       pkt1=-1.1455303e-014      kt1l=0
+ kt2=-0.074755392          lkt2=1.2928128e-008       wkt2=9.1098221e-010
+ pkt2=-1.8848206e-015      ute=-1.6000608            lute=3.6288112e-007
+ wute=1.0874474e-007       pute=-1.0026868e-013      ua1=-2.0149537e-009
+ lua1=1.8962287e-015       wua1=4.8517004e-016       pua1=-3.0387616e-022
+ ub1=-2.9233283e-019       lub1=-2.7083506e-024      wub1=1.0360222e-025
+ pub1=2.5270542e-032       uc1=1.1053328e-010        luc1=-8.5182307e-017
+ wuc1=-6.3840906e-018      puc1=1.3322513e-023       prt=0
+ at=76905.384              lat=-0.067797058          wat=0.0011022368
+ pat=-1.0821761e-008+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     15: type=p 
+ lmin=6e-007-dxlp_5-dxlmisp_5                        lmax=1.2e-006-dxlp_5-dxlmisp_5
+ wmin=2.2e-07              wmax=5e-007-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.68601503+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=4.780443e-008+dlvthp_5                        wvth0=1.1775557e-008+dwvthp_5
+ pvth0=-5.1993714e-016+dpvthp_5                      k1=0.97
+ k2=0.053639668+dk2p_5+dk2misp_5                     lk2=-5.6087022e-009+dlk2p_5
+ wk2=-1.2481788e-008+dwk2p_5                         pk2=2.1799907e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00074552869         lcit=1.2331861e-010       wcit=6.5366274e-012
+ pcit=-2.7819014e-017      voff=-0.21941137          lvoff=4.5739285e-008
+ wvoff=2.4624918e-008      pvoff=-1.084594e-014      nfactor=0.5
+ eta0=0.004                etab=-0.097371071         wetab=4.7246764e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=(0.014132645+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(-6.3473714e-010+dlu0p_5)*fu0misp_5
+ wu0=(-8.7193491e-010+dwu0p_5)*fu0misp_5             pu0=(1.3890406e-016+dpu0p_5)*fu0misp_5
+ ua=2.2671228e-009         lua=4.2312194e-016        wua=-2.31229e-016
+ pua=-2.0817983e-023       ub=-7.9871376e-020        lub=-5.1449519e-025
+ wub=-1.1967431e-026       pub=9.3750349e-032        uc=-6.031412e-011
+ luc=-7.7998002e-018       wuc=-1.48568e-017         puc=-2.1094355e-024
+ vsat=77632.475            lvsat=-0.0016916615+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-0.0012541264       pvsat=1.7518352e-009+dpvsatp_5
+ a0=1.1506591              la0=-2.6098805e-007+dla0p_5
+ wa0=2.0063886e-008        pa0=1.3310391e-013        ags=0.12077568+dagsp_5
+ lags=5.4517793e-008       wags=1.2046745e-009+dwagsp_5
+ pags=3.6263179e-016       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.01680243
+ lketa=-2.0070042e-010     wketa=5.6118233e-009      pketa=-9.040964e-016
+ dwg=0                     dwb=0                     pclm=0.42743201+dpclmp_5
+ lpclm=2.3337785e-008      wpclm=-8.0867696e-008+dwpclmp_5
+ ppclm=3.5411693e-014      pdiblc1=0                 pdiblc2=-0.00013112025+dpdiblc2p_5
+ lpdiblc2=2.3528041e-010   wpdiblc2=5.4202581e-012   ppdiblc2=-5.5178228e-018
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=139.98668          lalpha1=-5.2017143e-005
+ walpha1=-7.42155e-006     palpha1=1.0156601e-011    beta0=51.294675+dbeta0p_5
+ lbeta0=-4.2658528e-006    wbeta0=-9.0899261e-007    pbeta0=1.202986e-012+dpbeta0p_5
+ agidl=2.4298195e-011      lagidl=-7.2329796e-018    wagidl=4.6421394e-018
+ pagidl=5.01614e-024       bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.000379204         ltvoff=1.43373e-009       wtvoff=8.63497e-010
+ ptvoff=-3.56934e-016      kt1=-0.37071158           lkt1=-2.7374804e-008
+ wkt1=4.9952e-009          pkt1=1.8686003e-015       kt1l=0
+ kt2=-0.064173634          lkt2=2.1558985e-009       wkt2=-2.6206162e-009
+ pkt2=1.7103465e-015       ute=-1.0809083            lute=-1.6561616e-007
+ wute=-2.5316147e-008      pute=3.6205303e-014       ua1=1.0887407e-009
+ lua1=-1.2633322e-015      wua1=-2.9077612e-017      pua1=2.1962794e-022
+ ub1=-4.4849862e-018       lub1=1.5597705e-024       wub1=3.4156079e-025
+ pub1=-2.1697128e-031      uc1=-1.3781663e-011       luc1=4.1370305e-017
+ wuc1=8.9530482e-018       puc1=-2.2906945e-024      prt=0
+ at=50385.383              lat=-0.040799698          wat=-0.0093116061
+ pat=-2.2046888e-010+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     16: type=p 
+ lmin=5e-07                lmax=6e-007-dxlp_5-dxlmisp_5
+ wmin=2.2e-07              wmax=5e-007-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.69854491+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=5.3041919e-008+dlvthp_5                       wvth0=4.3368528e-008+dwvthp_5
+ pvth0=-1.3725799e-014+dpvthp_5                      k1=0.97
+ k2=0.079673196+dk2p_5+dk2misp_5                     lk2=-1.6490717e-008+dlk2p_5
+ wk2=-1.5138328e-008+dwk2p_5                         pk2=3.2904244e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00075179781         lcit=1.2069812e-010       wcit=-1.2768866e-010
+ pcit=2.8287155e-017       voff=0.041196009          lvoff=-6.3194598e-008
+ wvoff=-3.1134336e-008     pvoff=1.2461428e-014      nfactor=0.5
+ eta0=0.004                etab=-0.097371071         wetab=4.7246764e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=(0.013847383+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(-5.1549758e-010+dlu0p_5)*fu0misp_5
+ wu0=(-7.0630706e-010+dwu0p_5)*fu0misp_5             pu0=(6.9671616e-017+dpu0p_5)*fu0misp_5
+ ua=2.6946966e-009         lua=2.4439609e-016        wua=-1.4221793e-016
+ pua=-5.802461e-023        ub=-7.8032085e-019        lub=-2.2170731e-025
+ wub=1.3917021e-025        pub=3.0574817e-032        uc=2.1311914e-011
+ luc=-4.1919482e-017       wuc=-2.8882276e-017       puc=3.7532136e-024
+ vsat=91249.476            lvsat=-0.0073835683+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=0.00016240623       pvsat=1.1597246e-009+dpvsatp_5
+ a0=2.5641989              la0=-8.5184773e-007+dla0p_5
+ wa0=2.19676e-007          pa0=4.9666041e-014        ags=0.70362741+dagsp_5
+ lags=-1.8911423e-007      wags=-5.7947785e-008+dwagsp_5
+ pags=2.508836e-014        a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.057760806
+ lketa=1.6919901e-008      wketa=1.1085975e-008      pketa=-3.1922919e-015
+ dwg=0                     dwb=0                     pclm=0.43004365+dpclmp_5
+ lpclm=2.2246119e-008      wpclm=1.608996e-008+dwpclmp_5
+ ppclm=-5.1166074e-015     pdiblc1=0                 pdiblc2=-0.015473916+dpdiblc2p_5
+ lpdiblc2=6.6485691e-009   wpdiblc2=9.2140327e-010   ppdiblc2=-3.8839872e-016
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=33.579801          lalpha1=-7.5390695e-006
+ walpha1=6.735066e-005     palpha1=-2.1098183e-011   beta0=53.200316+dbeta0p_5
+ lbeta0=-5.0624105e-006    wbeta0=7.0606054e-006     pbeta0=-2.128306e-012+dpbeta0p_5
+ agidl=1.6847523e-010      lagidl=-6.7498981e-017    wagidl=-6.6318129e-017
+ pagidl=3.4677532e-023     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.0103797           ltvoff=-2.74649e-009      wtvoff=-7.95592e-010
+ ptvoff=3.36565e-016       kt1=-0.39182241           lkt1=-1.8550479e-008
+ wkt1=1.5303251e-008       pkt1=-2.4401652e-015      kt1l=0
+ kt2=-0.082188619          lkt2=9.6861621e-009       wkt2=3.2975229e-009
+ pkt2=-7.6343561e-016      ute=-1.6119213            lute=5.6347279e-008
+ wute=2.5569865e-007       pute=-8.1258884e-014      ua1=-2.8396336e-009
+ lua1=3.7872824e-016       wua1=1.686534e-015        pua1=-4.9749772e-022
+ ub1=2.1147124e-018        lub1=-1.1989035e-024      wub1=-2.0415288e-024
+ pub1=7.7916016e-031       uc1=1.0442141e-010        luc1=-8.0385789e-018
+ wuc1=-3.8770918e-017      puc1=1.7657923e-023       prt=0
+ at=-112018.51             lat=0.027085129           wat=0.0050642572
+ pat=-6.2295797e-009+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     } 
ends pch_5_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                     5V NMOS DEVICE MODELS                  
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
model nch_5 bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_5        lmax=900.01e-06           wmin=1e-005-dxwn_5
+ wmax=900.01e-06           version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.80837352+dvthn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       k1=0.9                    k2=0.0079679065+dk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.00053254            voff=-0.1221858           nfactor=0.5
+ eta0=0.2882+deta0n_5      etab=-0.47086             ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.054978+du0n_5        ua=4.8644942e-010         ub=2.07977e-018
+ ku0=-4.500000e-08         tku0=0.000000e+00         pku0=1.300000e-13
+ wku0=1.500000e-07         lku0=-1.400000e-07        uc=9.333e-011
+ vsat=98936                a0=1.8732798              kvsat=-5.000000e-02
+ ags=0.1950454+dagsn_5     a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.01917
+ dwg=0                     dwb=0                     pclm=0.099988
+ pdiblc1=0                 pdiblc2=0.00035793185+dpdiblc2n_5
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.02                pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=4e-008             alpha1=22.782             beta0=41.34+dbeta0n_5
+ agidl=1.6674e-013         bgidl=1.2e+009            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00180344          ltvoff=0                  wtvoff=0
+ ptvoff=0                  kt1=-0.3795984            kt1l=0
+ kt2=-0.069439             ute=-1.2445               ua1=3.3789114e-009
+ ub1=-3.3042e-018          uc1=5.9040106e-011        prt=0
+ at=120000                 fnoimod=1                 tnoimod=0
+ em=1.192e+007             ef=0.9                    noia=3.6e+41
+ noib=1.0e+023             noic=1e+006               lintnoi=1e-008
+ jss=2.72e-07              jsd=2.72e-07              jsws=1.32e-13
+ jswd=1.32e-13             jswgs=1.33e-13            jswgd=1.33e-13
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   jtsswgs=1e-009            jtsswgd=1e-009
+ njtsswg=30                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.726                 pbd=0.726                 cjs=cjn_5
+ cjd=cjn_5                 mjs=0.322                 mjd=0.322
+ pbsws=0.406               pbswd=0.406               cjsws=cjswn_5
+ cjswd=cjswn_5             mjsws=0.118               mjswd=0.118
+ pbswgs=0.659              pbswgd=0.659              cjswgs=cjswgn_5
+ cjswgd=cjswgn_5           mjswgs=0.307              mjswgd=0.307
+ tpb=0.00171               tcj=0.00099               tpbsw=0.0023
+ tcjsw=0.00125             tpbswg=0.00203            tcjswg=0.00122
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthn_5          wvth0=0+dwvthn_5
+ pvth0=0+dpvthn_5          lu0=0+dlu0n_5             wu0=0+dwu0n_5
+ pu0=0+dpu0n_5             lvsat=0+dlvsatn_5         pvsat=0+dpvsatn_5
+ lk2=0+dlk2n_5             wk2=0+dwk2n_5             pk2=0+dpk2n_5
+ pbeta0=0+dpbeta0n_5       lpdiblc2=0+dlpdiblc2n_5   wpdiblc2=0+dwpdiblc2n_5
+ ppdiblc2=0+dppdiblc2n_5   wags=0+dwagsn_5           weta0=0+dweta0n_5
+ ppclm=0+dppclmn_5         la0=0+dla0n_5             lua1=0+dlua1n_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=0.000000e+00         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=-6.000000e-09        lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        web=0.000000e+00          wec=0.000000e+00
+ kvth0we=1.250000e-02      pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09
+ lkvth0we=7.000000e-09     ku0we=-5.000000e-03       pku0we=0.000000e+00
+ wku0we=2.500000e-09       lku0we=0.000000e+00       k2we=4.000000e-07
+ pk2we=0.000000e+00        lk2we=1.000000e-09        wk2we=1.500000e-09
+ rshg=8.23                 minr=1e-3
 
 
     2: type=n 
+ lmin=1.2e-006-dxln_5      lmax=1e-005-dxln_5        wmin=1e-005-dxwn_5
+ wmax=900.01e-06           version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.80760233+dvthn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=7.5715486e-009+dlvthn_5
+ k1=0.9                    k2=0.007762618+dk2n_5     lk2=2.0155225e-009+dlk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.00053630429         lcit=-3.6957764e-011      voff=-0.12353949
+ lvoff=1.3290484e-008      nfactor=0.5               eta0=0.2882+deta0n_5
+ etab=-0.47086             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.054769541+du0n_5
+ ku0=-4.500000e-08         tku0=0.000000e+00         pku0=1.300000e-13
+ wku0=1.500000e-07         lku0=-1.400000e-07        lu0=2.0466469e-009+dlu0n_5
+ ua=5.2564879e-010         lua=-3.8485946e-016       ub=2.0440967e-018
+ lub=3.5024012e-025        uc=9.0244766e-011         luc=3.0290828e-017
+ vsat=100435.49            lvsat=-0.014722001+dlvsatn_5
+ kvsat=-5.000000e-02       a0=1.9093884              la0=-3.5451456e-007+dla0n_5
+ ags=0.19148171+dagsn_5    lags=3.4988349e-008       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.018382091         lketa=-7.7356892e-009     dwg=0
+ dwb=0                     pclm=0.08841843           lpclm=1.1359004e-007
+ pdiblc1=0                 pdiblc2=0.00031141988+dpdiblc2n_5
+ lpdiblc2=4.5665457e-010+dlpdiblc2n_5                pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=20.764278          lalpha1=1.9809997e-005    beta0=41.16185+dbeta0n_5
+ lbeta0=1.7490767e-006     agidl=1.2873158e-013      lagidl=3.7316665e-019
+ bgidl=1.1884318e+009      lbgidl=113.57641          cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00171909          ltvoff=8.28154e-010       wtvoff=0
+ ptvoff=0                  kt1=-0.38168383           lkt1=2.0474771e-008
+ kt1l=0                    kt2=-0.070591307          lkt2=1.1313346e-008
+ ute=-1.2466054            lute=2.0670906e-008       ua1=3.41564e-009
+ lua1=-3.6060135e-016+dlua1n_5                       ub1=-3.4474372e-018
+ lub1=1.4063031e-024       uc1=4.6083755e-011        luc1=1.2720546e-016
+ prt=0                     at=133551.58              lat=-0.13304942
+ fnoimod=1                 tnoimod=0                 em=1.192e+007
+ ef=0.9                    noia=3.6e+41              noib=1.0e+023
+ noic=1e+006               lintnoi=1e-008            jss=2.72e-07
+ jsd=2.72e-07              jsws=1.32e-13             jswd=1.32e-13
+ jswgs=1.33e-13            jswgd=1.33e-13            njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ jtsswgs=1e-009            jtsswgd=1e-009            njtsswg=30
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.726
+ pbd=0.726                 cjs=cjn_5                 cjd=cjn_5
+ mjs=0.322                 mjd=0.322                 pbsws=0.406
+ pbswd=0.406               cjsws=cjswn_5             cjswd=cjswn_5
+ mjsws=0.118               mjswd=0.118               pbswgs=0.659
+ pbswgd=0.659              cjswgs=cjswgn_5           cjswgd=cjswgn_5
+ mjswgs=0.307              mjswgd=0.307              tpb=0.00171
+ tcj=0.00099               tpbsw=0.0023              tcjsw=0.00125
+ tpbswg=0.00203            tcjswg=0.00122            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthn_5          pvth0=0+dpvthn_5          wu0=0+dwu0n_5
+ pu0=0+dpu0n_5             pvsat=0+dpvsatn_5         wk2=0+dwk2n_5
+ pk2=0+dpk2n_5             pbeta0=0+dpbeta0n_5       wpdiblc2=0+dwpdiblc2n_5
+ ppdiblc2=0+dppdiblc2n_5   wags=0+dwagsn_5           weta0=0+dweta0n_5
+ ppclm=0+dppclmn_5         saref=1.000000e-05        sbref=1.000000e-05
+ llodvth=1.000000e+00      wlodvth=1.000000e+00      wlod=0.000000e+00
+ steta0=0.000000e+00       lodeta0=1.000000e+00      stk2=-6.000000e-09
+ lodk2=1.000000e+00        llodku0=1.000000e+00      wlodku0=1.000000e+00
+ wpemod=1.000000e+00       scref=1.000000e-06        web=0.000000e+00
+ wec=0.000000e+00          kvth0we=1.250000e-02      pkvth0we=0.000000e+00
+ wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09     ku0we=-5.000000e-03
+ pku0we=0.000000e+00       wku0we=2.500000e-09       lku0we=0.000000e+00
+ k2we=4.000000e-07         pk2we=0.000000e+00        lk2we=1.000000e-09
+ wk2we=1.500000e-09        rshg=8.23                 minr=1e-3
 
 
     3: type=n 
+ lmin=6e-07                lmax=1.2e-006-dxln_5      wmin=1e-005-dxwn_5
+ wmax=900.01e-06           version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.76738559+dvthn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=4.851219e-008+dlvthn_5
+ k1=0.9                    k2=0.011304779+dk2n_5     lk2=-1.5903978e-009+dlk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.00044905973         lcit=5.1857191e-011       voff=-0.093139132
+ lvoff=-1.7657076e-008     nfactor=0.5               eta0=0.17547933+deta0n_5
+ leta0=1.1474964e-007      etab=-0.47086             ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.050851367+du0n_5     ku0=-4.500000e-08         tku0=0.000000e+00
+ pku0=1.300000e-13         wku0=1.500000e-07         lku0=-1.400000e-07
+ lu0=6.0353487e-009+dlu0n_5                          ua=-5.8285628e-010
+ lua=7.4359871e-016        ub=3.9505538e-018         lub=-1.5905331e-024
+ uc=2.0638667e-010         luc=-8.7941627e-017       vsat=91179.413
+ lvsat=-0.0052993135+dlvsatn_5                       kvsat=-5.000000e-02
+ a0=3.2748054              la0=-1.744509e-006+dla0n_5
+ ags=0.091151875+dagsn_5   lags=1.3712412e-007       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.03502443          lketa=9.2062117e-009      dwg=0
+ dwb=0                     pclm=0.21928846           lpclm=-1.9635656e-008
+ pdiblc1=0                 pdiblc2=-0.00018189333+dpdiblc2n_5
+ lpdiblc2=9.5884741e-010+dlpdiblc2n_5                pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=51.490493          lalpha1=-1.146929e-005    beta0=46.279733+dbeta0n_5
+ lbeta0=-3.4609285e-006    agidl=3.2654643e-013      lagidl=1.7179113e-019
+ bgidl=1.3139333e+009      lbgidl=-14.184133         cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00324983          ltvoff=-7.30142e-010      wtvoff=0
+ ptvoff=0                  kt1=-0.3800122            lkt1=1.8773048e-008
+ kt1l=0                    kt2=-0.062264667          lkt2=2.8368267e-009
+ ute=-1.1871473            lute=-3.9857415e-008      ua1=2.5451959e-009
+ lua1=5.2551072e-016+dlua1n_5                        ub1=-2.0862033e-018
+ lub1=2.0566993e-026       uc1=1.151325e-010         luc1=5.6913835e-017
+ prt=0                     at=-9978.9464             lat=0.013064652
+ fnoimod=1                 tnoimod=0                 em=1.192e+007
+ ef=0.9                    noia=3.6e+41              noib=1.0e+023
+ noic=1e+006               lintnoi=1e-008            jss=2.72e-07
+ jsd=2.72e-07              jsws=1.32e-13             jswd=1.32e-13
+ jswgs=1.33e-13            jswgd=1.33e-13            njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ jtsswgs=1e-009            jtsswgd=1e-009            njtsswg=30
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.726
+ pbd=0.726                 cjs=cjn_5                 cjd=cjn_5
+ mjs=0.322                 mjd=0.322                 pbsws=0.406
+ pbswd=0.406               cjsws=cjswn_5             cjswd=cjswn_5
+ mjsws=0.118               mjswd=0.118               pbswgs=0.659
+ pbswgd=0.659              cjswgs=cjswgn_5           cjswgd=cjswgn_5
+ mjswgs=0.307              mjswgd=0.307              tpb=0.00171
+ tcj=0.00099               tpbsw=0.0023              tcjsw=0.00125
+ tpbswg=0.00203            tcjswg=0.00122            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthn_5          pvth0=0+dpvthn_5          wu0=0+dwu0n_5
+ pu0=0+dpu0n_5             pvsat=0+dpvsatn_5         wk2=0+dwk2n_5
+ pk2=0+dpk2n_5             pbeta0=0+dpbeta0n_5       wpdiblc2=0+dwpdiblc2n_5
+ ppdiblc2=0+dppdiblc2n_5   wags=0+dwagsn_5           weta0=0+dweta0n_5
+ ppclm=0+dppclmn_5         saref=1.000000e-05        sbref=1.000000e-05
+ llodvth=1.000000e+00      wlodvth=1.000000e+00      wlod=0.000000e+00
+ steta0=0.000000e+00       lodeta0=1.000000e+00      stk2=-6.000000e-09
+ lodk2=1.000000e+00        llodku0=1.000000e+00      wlodku0=1.000000e+00
+ wpemod=1.000000e+00       scref=1.000000e-06        web=0.000000e+00
+ wec=0.000000e+00          kvth0we=1.250000e-02      pkvth0we=0.000000e+00
+ wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09     ku0we=-5.000000e-03
+ pku0we=0.000000e+00       wku0we=2.500000e-09       lku0we=0.000000e+00
+ k2we=4.000000e-07         pk2we=0.000000e+00        lk2we=1.000000e-09
+ wk2we=1.500000e-09        rshg=8.23                 minr=1e-3
 
 
     4: type=n 
+ lmin=1e-005-dxln_5        lmax=900.01e-06           wmin=1.2e-006-dxwn_5
+ wmax=1e-005-dxwn_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.80505613+dvthn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       wvth0=3.3207084e-008+dwvthn_5
+ k1=0.9                    k2=0.0064475561+dk2n_5    wk2=1.5218707e-008+dwk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.00053494488         wcit=-2.4072799e-011      voff=-0.12342822
+ wvoff=1.2436649e-008      nfactor=0.5               eta0=0.23509063+deta0n_5
+ weta0=5.3162484e-007+dweta0n_5                      etab=-0.46980675
+ wetab=-1.0543032e-008     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.056349975+du0n_5
+ ku0=-4.500000e-08         tku0=0.000000e+00         pku0=1.300000e-13
+ wku0=1.500000e-07         lku0=-1.400000e-07        wu0=-1.373347e-008+dwu0n_5
+ ua=5.4690809e-010         wua=-6.0519129e-016       ub=2.0893221e-018
+ wub=-9.5616771e-026       uc=9.6948587e-011         wuc=-3.6222061e-017
+ vsat=98936                a0=1.8835895              wa0=-1.0320032e-007
+ kvsat=-5.000000e-02       ags=0.19639914+dagsn_5    wags=-1.3550962e-008+dwagsn_5
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.018756262         wketa=-4.1415124e-009
+ dwg=0                     dwb=0                     pclm=0.07442785
+ wpclm=2.558571e-007       pdiblc1=0                 pdiblc2=0.00037430423+dpdiblc2n_5
+ wpdiblc2=-1.6388752e-010+dwpdiblc2n_5               pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=24.409588          walpha1=-1.6292151e-005   beta0=41.838575+dbeta0n_5
+ wbeta0=-4.9907358e-006    agidl=1.5423987e-013      wagidl=1.2512625e-019
+ bgidl=1.233e+009          wbgidl=-330.33            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00161981          ltvoff=0                  wtvoff=1.83809e-009
+ ptvoff=0                  kt1=-0.38041261           wkt1=8.1502321e-009
+ kt1l=0                    kt2=-0.069805025          wkt2=3.6639103e-009
+ ute=-1.2527088            wute=8.2169588e-008       ua1=3.4530108e-009
+ wua1=-7.4173537e-016      ub1=-3.365265e-018        wub1=6.112608e-025
+ uc1=5.9888908e-011        wuc1=-8.4965088e-018      prt=0
+ at=120000                 fnoimod=1                 tnoimod=0
+ em=1.192e+007             ef=0.9                    noia=3.6e+41
+ noib=1.0e+023             noic=1e+006               lintnoi=1e-008
+ jss=2.72e-07              jsd=2.72e-07              jsws=1.32e-13
+ jswd=1.32e-13             jswgs=1.33e-13            jswgd=1.33e-13
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   jtsswgs=1e-009            jtsswgd=1e-009
+ njtsswg=30                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.726                 pbd=0.726                 cjs=cjn_5
+ cjd=cjn_5                 mjs=0.322                 mjd=0.322
+ pbsws=0.406               pbswd=0.406               cjsws=cjswn_5
+ cjswd=cjswn_5             mjsws=0.118               mjswd=0.118
+ pbswgs=0.659              pbswgd=0.659              cjswgs=cjswgn_5
+ cjswgd=cjswgn_5           mjswgs=0.307              mjswgd=0.307
+ tpb=0.00171               tcj=0.00099               tpbsw=0.0023
+ tcjsw=0.00125             tpbswg=0.00203            tcjswg=0.00122
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthn_5          pvth0=0+dpvthn_5
+ lu0=0+dlu0n_5             pu0=0+dpu0n_5             lvsat=0+dlvsatn_5
+ pvsat=0+dpvsatn_5         lk2=0+dlk2n_5             pk2=0+dpk2n_5
+ pbeta0=0+dpbeta0n_5       lpdiblc2=0+dlpdiblc2n_5   ppdiblc2=0+dppdiblc2n_5
+ ppclm=0+dppclmn_5         la0=0+dla0n_5             lua1=0+dlua1n_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=0.000000e+00         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=-6.000000e-09        lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        web=0.000000e+00          wec=0.000000e+00
+ kvth0we=1.250000e-02      pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09
+ lkvth0we=7.000000e-09     ku0we=-5.000000e-03       pku0we=0.000000e+00
+ wku0we=2.500000e-09       lku0we=0.000000e+00       k2we=4.000000e-07
+ pk2we=0.000000e+00        lk2we=1.000000e-09        wk2we=1.500000e-09
+ rshg=8.23                 minr=1e-3
 
 
     5: type=n 
+ lmin=1.2e-006-dxln_5      lmax=1e-005-dxln_5        wmin=1.2e-006-dxwn_5
+ wmax=1e-005-dxwn_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.8041019+dvthn_5
+ lvth0=9.3686546e-009+dlvthn_5                       kvth0=7.000000e-09
+ pkvth0=0.000000e+00       wkvth0=1.000000e-08       lkvth0=3.800000e-07
+ wvth0=3.5039334e-008+dwvthn_5                       pvth0=-1.7989031e-014+dpvthn_5
+ k1=0.9                    k2=0.0062028859+dk2n_5    lk2=2.4021723e-009+dlk2n_5
+ wk2=1.5612918e-008+dwk2n_5                          pk2=-3.8703647e-015+dpk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.00053851399         lcit=-3.5041587e-011      wcit=-2.211915e-011
+ pcit=-1.9180922e-017      voff=-0.12501652          lvoff=1.5593896e-008
+ wvoff=1.4785107e-008      pvoff=-2.3057156e-014     nfactor=0.5
+ eta0=0.23509063+deta0n_5  weta0=5.3162484e-007+dweta0n_5
+ etab=-0.46980675          wetab=-1.0543032e-008     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.056192385+du0n_5     ku0=-4.500000e-08         tku0=0.000000e+00
+ pku0=1.300000e-13         wku0=1.500000e-07         lku0=-1.400000e-07
+ lu0=1.547223e-009+dlu0n_5 wu0=-1.424266e-008+dwu0n_5
+ pu0=4.9992329e-015+dpu0n_5                          ua=5.9642819e-010
+ lua=-4.8618832e-016       wua=-7.0850173e-016       pua=1.0143019e-021
+ ub=2.0399949e-018         lub=4.8429435e-025        wub=4.1059018e-026
+ pub=-1.3418829e-030       uc=9.3655284e-011         luc=3.2333656e-017
+ wuc=-3.4139284e-017       puc=-2.0448707e-023       vsat=100497.02
+ lvsat=-0.015326133+dlvsatn_5                        kvsat=-5.000000e-02
+ wvsat=-0.00061594607      pvsat=6.0473585e-009+dpvsatn_5
+ a0=1.9153848              la0=-3.1216609e-007+dla0n_5
+ wa0=-6.0023686e-008       pa0=-4.2390822e-013       ags=0.19263976+dagsn_5
+ lags=3.6909577e-008       wags=-1.1592163e-008+dwagsn_5
+ pags=-1.9231492e-014      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.018135528
+ lketa=-6.0943681e-009     wketa=-2.4680937e-009     pketa=-1.6429624e-014
+ dwg=0                     dwb=0                     pclm=0.060003235
+ lpclm=1.4162087e-007      wpclm=2.844361e-007       ppclm=-2.8058859e-013+dppclmn_5
+ pdiblc1=0                 pdiblc2=0.00033083149+dpdiblc2n_5
+ lpdiblc2=4.2681534e-010+dlpdiblc2n_5                wpdiblc2=-1.9431028e-010+dwpdiblc2n_5
+ ppdiblc2=2.9869064e-016+dppdiblc2n_5                pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=22.159284          lalpha1=2.2093479e-005    walpha1=-1.3964013e-005
+ palpha1=-2.2857656e-011   beta0=41.640208+dbeta0n_5 lbeta0=1.9475657e-006
+ wbeta0=-4.7883651e-006    pbeta0=-1.9868746e-012+dpbeta0n_5
+ agidl=1.2092412e-013      lagidl=3.270941e-019      wagidl=7.8152706e-020
+ pagidl=4.6118627e-025     bgidl=1.2217499e+009      lbgidl=110.45306
+ wbgidl=-333.51443         pbgidl=3.1264746e-005     cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.0015127           ltvoff=1.05165e-009       wtvoff=2.06597e-009
+ ptvoff=-2.23724e-015      kt1=-0.38265993           lkt1=2.2064156e-008
+ wkt1=9.7706984e-009       pkt1=-1.5909738e-014      kt1l=0
+ kt2=-0.070968084          lkt2=1.1418915e-008       wkt2=3.771544e-009
+ pkt2=-1.0567484e-015      ute=-1.2535464            lute=8.2243517e-009
+ wute=6.9479629e-008       pute=1.2459001e-013       ua1=3.4975823e-009
+ lua1=-4.3760281e-016+dlua1n_5                       wua1=-8.2024267e-016
+ pua1=7.7078463e-022       ub1=-3.514681e-018        lub1=1.466966e-024
+ wub1=6.7311003e-025       pub1=-6.0723578e-031      uc1=4.6585903e-011
+ luc1=1.306089e-016        wuc1=-5.026505e-018       puc1=-3.4068497e-023
+ prt=0                     at=133514.13              lat=-0.1326817
+ wat=0.00037491901         pat=-3.6809549e-009       fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
 
     6: type=n 
+ lmin=6e-07                lmax=1.2e-006-dxln_5      wmin=1.2e-006-dxwn_5
+ wmax=1e-005-dxwn_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.76722902+dvthn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=4.6905247e-008+dlvthn_5
+ wvth0=1.5673061e-009+dwvthn_5                       pvth0=1.6085493e-014+dpvthn_5
+ k1=0.9                    k2=0.0094853277+dk2n_5    lk2=-9.3935343e-010+dlk2n_5
+ wk2=1.8212711e-008+dwk2n_5                          pk2=-6.5169541e-015+dpk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.00045301475         lcit=5.1996639e-011       wcit=-3.9589729e-011
+ pcit=-1.3958721e-018      voff=-0.093593713         lvoff=-1.6394521e-008
+ wvoff=4.5503532e-009      pvoff=-1.2638177e-014     nfactor=0.5
+ eta0=0.10687087+deta0n_5  leta0=1.3052771e-007      weta0=6.8677075e-007+dweta0n_5
+ peta0=-1.5793853e-013     etab=-0.4698071           letab=3.510573e-013
+ wetab=-1.0539581e-008     petab=-3.5140836e-018     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.051447388+du0n_5     ku0=-4.500000e-08         tku0=0.000000e+00
+ pku0=1.300000e-13         wku0=1.500000e-07         lku0=-1.400000e-07
+ lu0=6.3776296e-009+dlu0n_5                          wu0=-5.9661727e-009+dwu0n_5
+ pu0=-3.4262315e-015+dpu0n_5                         ua=-6.2318912e-010
+ lua=7.553821e-016         wua=4.0373178e-016        pua=-1.1795181e-022
+ ub=4.0205006e-018         lub=-1.5318604e-024       wub=-7.0016807e-025
+ pub=-5.8731373e-031       uc=2.1059672e-010         luc=-8.6712731e-017
+ wuc=-4.2142685e-017       puc=-1.2301245e-023       vsat=91172.577
+ lvsat=-0.0058338463+dlvsatn_5                       kvsat=-5.000000e-02
+ wvsat=6.8420349e-005      pvsat=5.3506735e-009+dpvsatn_5
+ a0=3.3349865              la0=-1.7573207e-006+dla0n_5
+ wa0=-6.0241347e-007       pa0=1.2824459e-013        ags=0.10405873+dagsn_5
+ lags=1.2708507e-007       wags=-1.2919759e-007+dwagsn_5
+ pags=1.0049083e-013       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.029858935
+ lketa=5.8400598e-009      wketa=-5.1706605e-008     pketa=3.3695181e-014
+ dwg=0                     dwb=0                     pclm=0.21103124
+ lpclm=-1.2125642e-008     wpclm=8.265481e-008       ppclm=-7.5175238e-014+dppclmn_5
+ pdiblc1=0                 pdiblc2=-0.000209419+dpdiblc2n_5
+ lpdiblc2=9.7679034e-010+dlpdiblc2n_5                wpdiblc2=2.7553192e-010+dwpdiblc2n_5
+ ppdiblc2=-1.7960872e-016+dppdiblc2n_5               pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=56.438381          lalpha1=-1.2802641e-005   walpha1=-4.9528356e-005
+ palpha1=1.3346845e-011    beta0=47.038996+dbeta0n_5 lbeta0=-3.5484003e-006
+ wbeta0=-7.6002189e-006    pbeta0=8.7559249e-013+dpbeta0n_5
+ agidl=2.7602337e-013      lagidl=1.6920306e-019     wagidl=5.0573587e-019
+ pagidl=2.5906605e-026     bgidl=1.3413096e+009      lbgidl=-11.258656
+ wbgidl=-274.03626         pbgidl=-2.928403e-005     cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.0032725           ltvoff=-7.39821e-010      wtvoff=-2.26887e-010
+ ptvoff=9.68813e-017       kt1=-0.37877021           lkt1=1.8104429e-008
+ wkt1=-1.2432261e-008      pkt1=6.6928748e-015       kt1l=0
+ kt2=-0.062051216          lkt2=2.3415433e-009       wkt2=-2.1366433e-009
+ pkt2=4.9577862e-015       ute=-1.2121486            lute=-3.3918695e-008
+ wute=2.5026214e-007       pute=-5.944658e-014       ua1=2.6429158e-009
+ lua1=4.3244768e-016+dlua1n_5                        wua1=-9.7817623e-016
+ pua1=9.3156101e-022       ub1=-2.2553866e-018       lub1=1.8500434e-025
+ wub1=1.6935246e-024       pub1=-1.6460178e-030      uc1=1.1162367e-010
+ luc1=6.4400458e-017       wuc1=3.5123393e-017       puc1=-7.4941093e-023
+ prt=0                     at=-9761.8394             lat=0.013173236
+ wat=-0.0021732415         pat=-1.0869275e-009       fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
 
     7: type=n 
+ lmin=1e-005-dxln_5        lmax=900.01e-06           wmin=5e-007-dxwn_5
+ wmax=1.2e-006-dxwn_5      version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.82669732+dvthn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       wvth0=7.0212404e-009+dwvthn_5
+ k1=0.9                    k2=0.013780546+dk2n_5     wk2=6.3457892e-009+dwk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.00051556729         wcit=-6.2591571e-013      voff=-0.10123057
+ wvoff=-1.4422509e-008     nfactor=0.5               eta0=0.790526+deta0n_5
+ weta0=-1.4045196e-007+dweta0n_5                     etab=-0.50963
+ wetab=3.76431e-008        ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.047485886+du0n_5
+ ku0=-4.500000e-08         tku0=0.000000e+00         pku0=1.300000e-13
+ wku0=1.500000e-07         lku0=-1.400000e-07        wu0=-3.0079217e-009+dwu0n_5
+ ua=-3.0857429e-010        wua=4.2994239e-016        ub=2.5882757e-018
+ wub=-6.9935061e-025       uc=8.66939e-011           wuc=-2.3813889e-017
+ vsat=98937.457            wvsat=-1.7631429e-006     a0=1.8199091
+ kvsat=-5.000000e-02       wa0=-2.6147056e-008       ags=0.19077107+dagsn_5
+ wags=-6.7409976e-009+dwagsn_5                       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.027956571         wketa=6.9908614e-009      dwg=0
+ dwb=0                     pclm=0.42131706           wpclm=-1.6387884e-007
+ pdiblc1=0                 pdiblc2=0.0001991773+dpdiblc2n_5
+ wpdiblc2=4.8016066e-011+dwpdiblc2n_5                pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=12.541227          walpha1=-1.9314348e-006   beta0=38.597757+dbeta0n_5
+ wbeta0=-1.0693461e-006    agidl=5.6311719e-014      wagidl=2.4361932e-019
+ bgidl=9.8185714e+008      wbgidl=-26.447143         cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00379877          ltvoff=0                  wtvoff=-7.98439e-010
+ ptvoff=0                  kt1=-0.38308367           wkt1=1.1382216e-008
+ kt1l=0                    kt2=-0.0728817            wkt2=7.386687e-009
+ ute=-1.19245              wute=9.2565e-009          ua1=3.5079511e-009
+ wua1=-8.0821314e-016      ub1=-3.521117e-018        wub1=7.9984165e-025
+ uc1=7.9021232e-011        wuc1=-3.1646621e-017      prt=0
+ at=120000                 fnoimod=1                 tnoimod=0
+ em=1.192e+007             ef=0.9                    noia=3.6e+41
+ noib=1.0e+023             noic=1e+006               lintnoi=1e-008
+ jss=2.72e-07              jsd=2.72e-07              jsws=1.32e-13
+ jswd=1.32e-13             jswgs=1.33e-13            jswgd=1.33e-13
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   jtsswgs=1e-009            jtsswgd=1e-009
+ njtsswg=30                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.726                 pbd=0.726                 cjs=cjn_5
+ cjd=cjn_5                 mjs=0.322                 mjd=0.322
+ pbsws=0.406               pbswd=0.406               cjsws=cjswn_5
+ cjswd=cjswn_5             mjsws=0.118               mjswd=0.118
+ pbswgs=0.659              pbswgd=0.659              cjswgs=cjswgn_5
+ cjswgd=cjswgn_5           mjswgs=0.307              mjswgd=0.307
+ tpb=0.00171               tcj=0.00099               tpbsw=0.0023
+ tcjsw=0.00125             tpbswg=0.00203            tcjswg=0.00122
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthn_5          pvth0=0+dpvthn_5
+ lu0=0+dlu0n_5             pu0=0+dpu0n_5             lvsat=0+dlvsatn_5
+ pvsat=0+dpvsatn_5         lk2=0+dlk2n_5             pk2=0+dpk2n_5
+ pbeta0=0+dpbeta0n_5       lpdiblc2=0+dlpdiblc2n_5   ppdiblc2=0+dppdiblc2n_5
+ ppclm=0+dppclmn_5         la0=0+dla0n_5             lua1=0+dlua1n_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=0.000000e+00         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=-6.000000e-09        lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        web=0.000000e+00          wec=0.000000e+00
+ kvth0we=1.250000e-02      pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09
+ lkvth0we=7.000000e-09     ku0we=-5.000000e-03       pku0we=0.000000e+00
+ wku0we=2.500000e-09       lku0we=0.000000e+00       k2we=4.000000e-07
+ pk2we=0.000000e+00        lk2we=1.000000e-09        wk2we=1.500000e-09
+ rshg=8.23                 minr=1e-3
 
 
     8: type=n 
+ lmin=1.2e-006-dxln_5      lmax=1e-005-dxln_5        wmin=5e-007-dxwn_5
+ wmax=1.2e-006-dxwn_5      version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.82930583+dvthn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=-2.5610351e-008+dlvthn_5
+ wvth0=4.5425721e-009+dwvthn_5                       pvth0=2.4335566e-014+dpvthn_5
+ k1=0.9                    k2=0.013374856+dk2n_5     lk2=3.9830663e-009+dlk2n_5
+ wk2=6.9348344e-009+dwk2n_5                          pk2=-5.7832464e-015+dpk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.00050829488         lcit=7.1400459e-011       wcit=1.4445972e-011
+ pcit=-1.479758e-016       voff=-0.099771461         lvoff=-1.4325543e-008
+ wvoff=-1.5761413e-008     pvoff=1.3145365e-014      nfactor=0.5
+ eta0=0.790526+deta0n_5    weta0=-1.4045196e-007+dweta0n_5
+ etab=-0.50963             wetab=3.76431e-008        ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.046972206+du0n_5     ku0=-4.500000e-08         tku0=0.000000e+00
+ pku0=1.300000e-13         wku0=1.500000e-07         lku0=-1.400000e-07
+ lu0=5.0433118e-009+dlu0n_5                          wu0=-3.0862437e-009+dwu0n_5
+ pu0=7.6896551e-016+dpu0n_5                          ua=-3.459704e-010
+ lua=3.6715509e-016        wua=4.3180057e-016        pua=-1.8243617e-023
+ ub=2.6425042e-018         lub=-5.3241571e-025       wub=-6.8797725e-025
+ pub=-1.1166372e-031       uc=8.4829239e-011         luc=1.8307246e-017
+ wuc=-2.3459769e-017       puc=-3.4767504e-024       vsat=100424.31
+ lvsat=-0.014597905+dlvsatn_5                        kvsat=-5.000000e-02
+ wvsat=-0.00052796019      pvsat=5.1662027e-009+dpvsatn_5
+ a0=1.8609205              la0=-4.0264925e-007+dla0n_5
+ wa0=5.8781618e-009        pa0=-3.1442359e-013       ags=0.18836619+dagsn_5
+ lags=2.3611106e-008       wags=-6.421142e-009+dwagsn_5
+ pags=-3.140343e-015       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.026124068
+ lketa=-1.7991522e-008     wketa=7.1980389e-009      pketa=-2.034068e-015
+ dwg=0                     dwb=0                     pclm=0.43799818
+ lpclm=-1.6377522e-007     wpclm=-1.7293778e-007     ppclm=8.8940673e-014+dppclmn_5
+ pdiblc1=0                 pdiblc2=0.00016356963+dpdiblc2n_5
+ lpdiblc2=3.4959612e-010+dlpdiblc2n_5                wpdiblc2=8.0765774e-012+dwpdiblc2n_5
+ ppdiblc2=3.921259e-016+dppdiblc2n_5                 pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=11.692175          lalpha1=8.3359941e-006    walpha1=-1.2988112e-006
+ palpha1=-6.2110986e-012   beta0=38.208775+dbeta0n_5 lbeta0=3.819023e-006
+ wbeta0=-6.3633148e-007    pbeta0=-4.251338e-012+dpbeta0n_5
+ agidl=1.0869076e-014      lagidl=4.4615587e-019     wagidl=2.1131931e-019
+ pagidl=3.1712152e-025     bgidl=9.671325e+008       lbgidl=144.56654
+ wbgidl=-25.427325         pbgidl=-1.0012572e-005    cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00401116          ltvoff=-2.08525e-009      wtvoff=-9.5717e-010
+ ptvoff=1.55842e-015       kt1=-0.38289911           lkt1=-1.8119734e-009
+ wkt1=1.0060115e-008       pkt1=1.2980378e-014       kt1l=0
+ kt2=-0.073946282          lkt2=1.0452064e-008       wkt2=7.3751631e-009
+ pkt2=1.1314206e-016       ute=-1.2087985            lute=1.6050943e-007
+ wute=1.5334614e-008       pute=-5.9674927e-014      ua1=3.60148e-009
+ lua1=-9.1826621e-016+dlua1n_5                       wua1=-9.4595884e-016
+ pua1=1.3523874e-021       ub1=-3.8804367e-018       lub1=3.5278007e-024
+ wub1=1.1156744e-024       pub1=-3.1008458e-030      uc1=6.5210285e-011
+ luc1=1.3559588e-016       wuc1=-2.7562007e-017      puc1=-4.0102741e-023
+ prt=0                     at=133444.71              lat=-0.13200013
+ wat=0.00045891804         pat=-4.5056573e-009       fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
 
     9: type=n 
+ lmin=6e-07                lmax=1.2e-006-dxln_5      wmin=5e-007-dxwn_5
+ wmax=1.2e-006-dxwn_5      version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.74461155+dvthn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=6.0608426e-008+dlvthn_5
+ wvth0=2.8934437e-008+dwvthn_5                       pvth0=-4.9535265e-016+dpvthn_5
+ k1=0.9                    k2=0.02555766+dk2n_5      lk2=-8.419028e-009+dlk2n_5
+ wk2=-1.2348105e-009+dwk2n_5                         pk2=2.5334521e-015+dpk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.000684095           lcit=-1.0756406e-010      wcit=-3.1919683e-010
+ pcit=1.9167257e-016       voff=-0.081258158         lvoff=-3.3172086e-008
+ wvoff=-1.0375668e-008     pvoff=7.6626764e-015      nfactor=0.5
+ eta0=0.79052525+deta0n_5  leta0=7.6472742e-013      weta0=-1.4045105e-007+dweta0n_5
+ peta0=-9.2532018e-019     etab=-0.50962414          letab=-5.968582e-012
+ wetab=3.763904e-008       petab=4.13268e-018        ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.049785028+du0n_5     ku0=-4.500000e-08         tku0=0.000000e+00
+ pku0=1.300000e-13         wku0=1.500000e-07         lku0=-1.400000e-07
+ lu0=2.1798581e-009+dlu0n_5                          wu0=-3.9547177e-009+dwu0n_5
+ pu0=1.653072e-015+dpu0n_5 ua=-1.0142233e-009        lua=1.0474365e-015
+ wua=8.7688311e-016        pua=-4.7133765e-022       ub=5.1807977e-018
+ lub=-3.1163984e-024       wub=-2.1041275e-024       pub=1.3299772e-030
+ uc=2.0330092e-010         luc=-1.0229693e-016       wuc=-3.3314763e-017
+ puc=6.555634e-024         vsat=87293.422            lvsat=-0.001230663+dlvsatn_5
+ kvsat=-5.000000e-02       wvsat=0.0047621979        pvsat=-2.1917834e-010+dpvsatn_5
+ a0=3.3839374              la0=-1.9530805e-006+dla0n_5
+ wa0=-6.6164404e-007       pa0=3.6511402e-013        ags=0.026956951+dagsn_5
+ lags=1.8792572e-007       wags=-3.590444e-008+dwagsn_5
+ pags=2.6873655e-014       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.064148324
+ lketa=2.0717171e-008      wketa=-1.0216445e-008     pketa=1.5693877e-014
+ dwg=0                     dwb=0                     pclm=0.39846434
+ lpclm=-1.2352977e-007     wpclm=-1.4413924e-007     ppclm=5.9623756e-014+dppclmn_5
+ pdiblc1=0                 pdiblc2=-0.00030986932+dpdiblc2n_5
+ lpdiblc2=8.3155697e-010+dlpdiblc2n_5                wpdiblc2=3.9707681e-010+dwpdiblc2n_5
+ ppdiblc2=-3.8763413e-018+dppdiblc2n_5               pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=22.269014          lalpha1=-2.4312277e-006   walpha1=-8.1834211e-006
+ palpha1=7.9743417e-013    beta0=45.03507+dbeta0n_5  lbeta0=-3.1301444e-006
+ wbeta0=-5.1754678e-006    pbeta0=3.6950285e-013+dpbeta0n_5
+ agidl=3.4606361e-013      lagidl=1.0492784e-019     wagidl=4.2098718e-019
+ pagidl=1.0367962e-025     bgidl=1.1490519e+009      lbgidl=-40.62741
+ wbgidl=-41.404471         pbgidl=6.2521633e-006     cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00217817          ltvoff=-2.19276e-010      wtvoff=1.09725e-009
+ ptvoff=-5.32978e-016      kt1=-0.43009901           lkt1=4.6237518e-008
+ wkt1=4.9675578e-008       pkt1=-2.7348163e-014      kt1l=0
+ kt2=-0.073614421          lkt2=1.0114229e-008       wkt2=1.1854835e-008
+ pkt2=-4.4471638e-015      ute=-1.0284849            lute=-2.3049809e-008
+ wute=2.8029118e-008       pute=-7.2597932e-014      ua1=8.8484524e-010
+ lua1=1.8472679e-015+dlua1n_5                        wua1=1.1490892e-015
+ pua1=-7.8037152e-022      ub1=2.007084e-018         lub1=-2.4656953e-024
+ wub1=-3.4640649e-024      pub1=1.5613287e-030       uc1=2.2106073e-010
+ luc1=-2.3059874e-017      wuc1=-9.7295454e-017      puc1=3.0885908e-023
+ prt=0                     at=-8122.1241             lat=0.012114908
+ wat=-0.0041572969         pat=1.9364951e-010        fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
 
     10: type=n 
+ lmin=1e-005-dxln_5        lmax=900.01e-06           wmin=2.2e-07
+ wmax=5e-007-dxwn_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.85493656+dvthn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       wvth0=-7.3807716e-009+dwvthn_5
+ k1=0.9                    k2=0.02270344+dk2n_5      wk2=1.7951131e-009+dwk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.0008322575          wcit=-1.6213792e-010      voff=-0.14342582
+ wvoff=7.0970689e-009      nfactor=0.5               eta0=0.66223964+deta0n_5
+ weta0=-7.5025918e-008+dweta0n_5                     etab=-0.44027214
+ wetab=2.2705929e-009      ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.044771857+du0n_5
+ ku0=-4.500000e-08         tku0=0.000000e+00         pku0=1.300000e-13
+ wku0=1.500000e-07         lku0=-1.400000e-07        wu0=-1.6237671e-009+dwu0n_5
+ ua=1.9882251e-010         wua=1.7117002e-016        ub=1.4961553e-018
+ wub=-1.4236922e-025       uc=7.2857143e-011         wuc=-1.6757143e-017
+ vsat=102183.57            wvsat=-0.0016572814       a0=1.7269313
+ kvsat=-5.000000e-02       wa0=2.1271643e-008        ags=0.1715329+dagsn_5
+ wags=3.0704699e-009+dwagsn_5                        a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.013201339         wketa=-5.3430736e-010     dwg=0
+ dwb=0                     pclm=0.017831643          wpclm=4.1898722e-008
+ pdiblc1=0                 pdiblc2=0.00025327298+dpdiblc2n_5
+ wpdiblc2=2.0427271e-011+dwpdiblc2n_5                pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=-0.63803214        walpha1=4.7899874e-006    beta0=32.623036+dbeta0n_5
+ wbeta0=1.9777618e-006     agidl=2.078457e-013       wagidl=1.6633699e-019
+ bgidl=9.5464286e+008      wbgidl=-12.567857         cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.000434025         ltvoff=0                  wtvoff=9.17579e-010
+ ptvoff=0                  kt1=-0.38494998           wkt1=1.2334032e-008
+ kt1l=0                    kt2=-0.069070821          wkt2=5.4431389e-009
+ ute=-1.1954929            wute=1.0808357e-008       ua1=1.8730734e-009
+ wua1=2.55745e-017         ub1=-1.2119536e-018       wub1=-3.7783168e-025
+ uc1=6.0503534e-011        wuc1=-2.2202595e-017      prt=0
+ at=120000                 fnoimod=1                 tnoimod=0
+ em=1.192e+007             ef=0.9                    noia=3.6e+41
+ noib=1.0e+023             noic=1e+006               lintnoi=1e-008
+ jss=2.72e-07              jsd=2.72e-07              jsws=1.32e-13
+ jswd=1.32e-13             jswgs=1.33e-13            jswgd=1.33e-13
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   jtsswgs=1e-009            jtsswgd=1e-009
+ njtsswg=30                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.726                 pbd=0.726                 cjs=cjn_5
+ cjd=cjn_5                 mjs=0.322                 mjd=0.322
+ pbsws=0.406               pbswd=0.406               cjsws=cjswn_5
+ cjswd=cjswn_5             mjsws=0.118               mjswd=0.118
+ pbswgs=0.659              pbswgd=0.659              cjswgs=cjswgn_5
+ cjswgd=cjswgn_5           mjswgs=0.307              mjswgd=0.307
+ tpb=0.00171               tcj=0.00099               tpbsw=0.0023
+ tcjsw=0.00125             tpbswg=0.00203            tcjswg=0.00122
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthn_5          pvth0=0+dpvthn_5
+ lu0=0+dlu0n_5             pu0=0+dpu0n_5             lvsat=0+dlvsatn_5
+ pvsat=0+dpvsatn_5         lk2=0+dlk2n_5             pk2=0+dpk2n_5
+ pbeta0=0+dpbeta0n_5       lpdiblc2=0+dlpdiblc2n_5   ppdiblc2=0+dppdiblc2n_5
+ ppclm=0+dppclmn_5         la0=0+dla0n_5             lua1=0+dlua1n_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=0.000000e+00         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=-6.000000e-09        lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        web=0.000000e+00          wec=0.000000e+00
+ kvth0we=1.250000e-02      pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09
+ lkvth0we=7.000000e-09     ku0we=-5.000000e-03       pku0we=0.000000e+00
+ wku0we=2.500000e-09       lku0we=0.000000e+00       k2we=4.000000e-07
+ pk2we=0.000000e+00        lk2we=1.000000e-09        wk2we=1.500000e-09
+ rshg=8.23                 minr=1e-3
 
 
     11: type=n 
+ lmin=1.2e-006-dxln_5      lmax=1e-005-dxln_5        wmin=2.2e-07
+ wmax=5e-007-dxwn_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.84930892+dvthn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=5.5252147e-008+dlvthn_5
+ wvth0=-5.6590045e-009+dwvthn_5                      pvth0=-1.6904308e-014+dpvthn_5
+ k1=0.9                    k2=0.022517101+dk2n_5     lk2=1.8294789e-009+dlk2n_5
+ wk2=2.2722894e-009+dwk2n_5                          pk2=-4.6849168e-015+dpk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.00088386803         lcit=-5.0671222e-010      wcit=-1.7709634e-010
+ pcit=1.4686167e-016       voff=-0.14398747          lvoff=5.5142985e-009
+ wvoff=6.788753e-009       pvoff=3.0270462e-015      nfactor=0.5
+ eta0=0.66223964+deta0n_5  weta0=-7.5025918e-008+dweta0n_5
+ etab=-0.44027214          wetab=2.2705929e-009      ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.04406669+du0n_5      lu0=6.923334e-009+dlu0n_5 ku0=-4.500000e-08
+ tku0=0.000000e+00         pku0=1.300000e-13         wku0=1.500000e-07
+ lku0=-1.400000e-07        wu0=-1.6044306e-009+dwu0n_5
+ pu0=-1.8984581e-016+dpu0n_5                         ua=1.1518091e-010
+ lua=8.2119321e-016        wua=1.966134e-016         pua=-2.4980306e-022
+ ub=1.6296063e-018         lub=-1.310222e-024        wub=-1.7139932e-025
+ pub=2.8501746e-031        uc=7.1369726e-011         luc=1.4603463e-017
+ wuc=-1.6595417e-017       puc=-1.5878212e-024       vsat=101846.64
+ lvsat=0.0033080346+dlvsatn_5                        kvsat=-5.000000e-02
+ wvsat=-0.0012533472       pvsat=-3.9658266e-009+dpvsatn_5
+ a0=1.8464214              la0=-1.1731538e-006+dla0n_5
+ wa0=1.3272688e-008        pa0=7.8533739e-014        ags=0.17210017+dagsn_5
+ lags=-5.5694387e-009      wags=1.8745304e-009+dwagsn_5
+ pags=1.1741735e-014       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.0081260584
+ lketa=-4.9829099e-008     wketa=-1.9809458e-009     pketa=1.4203097e-014
+ dwg=0                     dwb=0                     pclm=0.015861751
+ lpclm=1.9340399e-008      wpclm=4.2351797e-008      ppclm=-4.4482919e-015+dppclmn_5
+ pdiblc1=0                 pdiblc2=9.9360562e-005+dpdiblc2n_5
+ lpdiblc2=1.5111121e-009+dlpdiblc2n_5                wpdiblc2=4.0823201e-011+dwpdiblc2n_5
+ ppdiblc2=-2.0024724e-016+dppdiblc2n_5               pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=-0.98495654        lalpha1=3.4061038e-006    walpha1=5.1665259e-006
+ palpha1=-3.6968546e-012   beta0=32.862741+dbeta0n_5 lbeta0=-2.3534249e-006
+ wbeta0=2.0901461e-006     pbeta0=-1.1033895e-012+dpbeta0n_5
+ agidl=9.6403952e-014      lagidl=1.0941351e-018     wagidl=1.6769652e-019
+ pagidl=-1.3347892e-026    bgidl=9.3716664e+008      lbgidl=171.5815
+ wbgidl=-10.144736         pbgidl=-2.3790201e-005    cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.000236425         ltvoff=1.94004e-009       wtvoff=9.67944e-010
+ ptvoff=-4.94484e-016      kt1=-0.38766554           lkt1=2.6661403e-008
+ wkt1=1.2490993e-008       pkt1=-1.5410436e-015      kt1l=0
+ kt2=-0.070917529          lkt2=1.8130973e-008       wkt2=5.830499e-009
+ pkt2=-3.8031016e-015      ute=-1.2033444            lute=7.7085931e-008
+ wute=1.2553004e-008       pute=-1.7128945e-014      ua1=1.6456291e-009
+ lua1=2.233048e-015+dlua1n_5                         wua1=5.1525088e-017
+ pua1=-2.5478287e-022      ub1=-8.1175127e-019       lub1=-3.9291862e-024
+ wub1=-4.4935516e-025      pub1=7.0221756e-031       uc1=5.7969388e-011
+ luc1=2.488025e-017        wuc1=-2.386915e-017       puc1=1.6362232e-023
+ prt=0                     at=134531.91              lat=-0.14267429
+ wat=-9.5555697e-005       pat=9.3816583e-010        fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
 
     12: type=n 
+ lmin=6e-07                lmax=1.2e-006-dxln_5      wmin=2.2e-07
+ wmax=5e-007-dxwn_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5
+ toxm=toxn_5               dtox=7e-010               epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5          xw=1e-08+dxwn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.82128748+dvthn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=8.3777975e-008+dlvthn_5
+ wvth0=-1.0170287e-008+dwvthn_5                      pvth0=-1.2311823e-014+dpvthn_5
+ k1=0.9                    k2=0.042151883+dk2n_5     lk2=-1.8158729e-008+dlk2n_5
+ wk2=-9.6978645e-009+dwk2n_5                         pk2=7.5006999e-015+dpk2n_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=-2.4276794e-005       lcit=4.1777921e-010       wcit=4.2072787e-011
+ pcit=-7.6252495e-017      voff=-0.094444408         lvoff=-4.4920541e-008
+ wvoff=-3.65068e-009       pvoff=1.3654389e-014      nfactor=0.5
+ eta0=0.66224009+deta0n_5  leta0=-4.5541199e-013     weta0=-7.502562e-008+dweta0n_5
+ peta0=-3.0304907e-019     etab=-0.4402747           letab=2.6007622e-012
+ wetab=2.2708263e-009      petab=-2.3768555e-019     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.045127397+du0n_5     ku0=-4.500000e-08         tku0=0.000000e+00
+ pku0=1.300000e-13         wku0=1.500000e-07         lku0=-1.400000e-07
+ lu0=5.8435337e-009+dlu0n_5                          wu0=-1.5793258e-009+dwu0n_5
+ pu0=-2.1540253e-016+dpu0n_5                         ua=1.0390909e-009
+ lua=-1.1934713e-016       wua=-1.7030711e-016       pua=1.2372201e-022
+ ub=-1.1127047e-019        lub=4.6199064e-025        wub=5.9482727e-025
+ pub=-4.950012e-031        uc=1.7090784e-010         luc=-8.6726332e-017
+ wuc=-1.6794289e-017       puc=-1.3853702e-024       vsat=108859.1
+ lvsat=-0.0038306584+dlvsatn_5                       kvsat=-5.000000e-02
+ wvsat=-0.0062362999       pvsat=1.1068193e-009+dpvsatn_5
+ a0=1.9212866              la0=-1.2493666e-006+dla0n_5
+ wa0=8.4307893e-008        pa0=6.2199001e-015        ags=-0.092172064+dagsn_5
+ lags=2.6345969e-007       wags=2.4851357e-008+dwagsn_5
+ pags=-1.1648675e-014      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.11720697
+ lketa=6.1215273e-008      wketa=1.6843467e-008      pketa=-4.9601554e-015
+ dwg=0                     dwb=0                     pclm=0.037620969
+ lpclm=-2.8104847e-009     wpclm=3.9890881e-008      ppclm=-1.9430794e-015+dppclmn_5
+ pdiblc1=0                 pdiblc2=0.00061380085+dpdiblc2n_5
+ lpdiblc2=9.8741187e-010+dlpdiblc2n_5                wpdiblc2=-7.3994973e-011+dwpdiblc2n_5
+ ppdiblc2=-8.3362338e-017+dppdiblc2n_5               pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=1.0024029          lalpha1=1.3829719e-006    walpha1=2.6625504e-006
+ palpha1=-1.1478076e-012   beta0=30.535129+dbeta0n_5 lbeta0=1.6083794e-008
+ wbeta0=2.2195017e-006     pbeta0=-1.2350735e-012+dpbeta0n_5
+ agidl=7.8355508e-013      lagidl=3.9461525e-019     wagidl=1.9786653e-019
+ pagidl=-4.4060959e-026    bgidl=1.1507488e+009      lbgidl=-45.845145
+ wbgidl=-42.269893         pbgidl=8.9132081e-006     cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00304649          ltvoff=-9.20602e-010      wtvoff=6.54406e-010
+ ptvoff=-1.75302e-016      kt1=-0.36979957           lkt1=8.4738492e-009
+ wkt1=1.8922868e-008       pkt1=-8.0886918e-015      kt1l=0
+ kt2=-0.052638684          lkt2=-4.7689083e-010      wkt2=1.1572092e-009
+ pkt2=9.5430748e-016       ute=-0.93417846           lute=-1.9692495e-007
+ wute=-2.0067165e-008      pute=1.6078388e-014       ua1=4.1009723e-009
+ lua1=-2.6649144e-016+dlua1n_5                       wua1=-4.9113566e-016
+ pua1=2.9764577e-022       ub1=-6.8119874e-018       lub1=2.1790541e-024
+ wub1=1.0336616e-024       pub1=-8.0749345e-031      uc1=2.9719368e-011
+ luc1=5.363877e-017        wuc1=2.8864205e-019       puc1=-8.2303999e-024
+ prt=0                     at=-17406.274             lat=0.011998783
+ wat=0.00057761944         pat=2.5287354e-010        fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
 
// *********************************************************************************************
//                                                                            
//                   *
//                                    5V PMOS DEVICE MODELS                   
//                   *
//                                                                            
//                   *
// *********************************************************************************************
     } 
model pch_5 bsim4  { 
     1: type=p 
+ lmin=1e-005-dxlp_5        lmax=900.01e-6            wmin=1e-005-dxwp_5
+ wmax=900.01e-6            version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.68990316+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ k1=0.97                   k2=0.037302147+dk2p_5     k3=0
+ k3b=0                     w0=0                      dvt0=4.0687
+ dvt1=0.52816              dvt2=0.054                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56029329
+ minv=-0.1944              voffl=0                   dvtp0=4.3355e-007
+ dvtp1=0.1                 lpe0=7.3862e-008          lpeb=1e-008
+ xj=1.5e-007               ngate=1.5e+021            ndep=1.424026e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0015              cdscd=0                   cit=0.00078879
+ voff=-0.16297451          nfactor=0.5               eta0=0.004
+ etab=-0.064227            ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.015475+du0p_5
+ ua=2.34e-009              ub=1.3498624e-019         ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         uc=-6.4e-011              vsat=77087.124
+ a0=1.2903138              kvsat=-2.550000e-01       ags=0.12003137+dagsp_5
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.008773             dwg=0
+ dwb=0                     pclm=0.2993+dpclmp_5      pdiblc1=0
+ pdiblc2=0.00048+dpdiblc2p_5                         pdiblcb=-0.2
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=4.11e+008          pscbe2=1e-006             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.49                  rdsw=1000                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=187                beta0=49.325+dbeta0p_5    agidl=5.9232e-012
+ bgidl=1.0679e+009         cgidl=150                 egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_5               cgdo=cgop_5               cgbo=0
+ cgdl=cglp_5               cgsl=cglp_5               clc=1e-007
+ cle=0.6                   cf=cfp_5                  ckappas=0.6
+ ckappad=0.6               acde=1                    moin=25
+ noff=2                    voffcv=-0.02              tvoff=0.0025448
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ kt1=-0.36894              kt1l=0                    kt2=-0.05209992
+ ute=-1.2367               ua1=-7.1436e-011          ub1=-1.26e-018
+ uc1=5.6e-011              prt=0                     at=70000
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=1.67e+41             noib=1.612e+24
+ noic=3.5e9                lintnoi=-1e-7             jss=1.94e-07
+ jsd=1.94e-07              jsws=7.03e-14             jswd=7.03e-14
+ jswgs=8.1e-14             jswgd=8.1e-14             njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=8.4
+ bvd=8.4                   xjbvs=1                   xjbvd=1
+ jtsswgs=5.2e-010          jtsswgd=5.2e-010          njtsswg=30
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1.5
+ vtsswgs=19.9              vtsswgd=19.9              pbs=0.822
+ pbd=0.822                 cjs=cjp_5                 cjd=cjp_5
+ mjs=0.367                 mjd=0.367                 pbsws=0.767
+ pbswd=0.767               cjsws=cjswp_5             cjswd=cjswp_5
+ mjsws=0.275               mjswd=0.275               pbswgs=0.783
+ pbswgd=0.783              cjswgs=cjswgp_5           cjswgd=cjswgp_5
+ mjswgs=0.361              mjswgd=0.361              tpb=0.00165
+ tcj=0.000954              tpbsw=0.0016              tcjsw=0.0007
+ tpbswg=0.00187            tcjswg=0.00115            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lvth0=0+dlvthp_5          wvth0=0+dwvthp_5          pvth0=0+dpvthp_5
+ lu0=0+dlu0p_5             wu0=0+dwu0p_5             pu0=0+dpu0p_5
+ lk2=0+dlk2p_5             wk2=0+dwk2p_5             pk2=0+dpk2p_5
+ lvsat=0+dlvsatp_5         pvsat=0+dpvsatp_5         pbeta0=0+dpbeta0p_5
+ wpclm=0+dwpclmp_5         wags=0+dwagsp_5           la0=0+dla0p_5
+ pat=0+dpatp_5             saref=1.000000e-05        sbref=1.000000e-05
+ llodvth=1.000000e+00      wlodvth=1.000000e+00      wlod=1.700000e-06
+ steta0=0.000000e+00       lodeta0=1.000000e+00      stk2=6.000000e-09
+ lodk2=1.000000e+00        llodku0=1.000000e+00      wlodku0=1.000000e+00
+ wpemod=1.000000e+00       scref=1.000000e-06        wec=0.000000e+00
+ web=0.000000e+00          kvth0we=-8.500000e-03     pkvth0we=0.000000e+00
+ wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09     ku0we=-2.500000e-03
+ pku0we=0.000000e+00       wku0we=1.000000e-09       lku0we=0.000000e+00
+ k2we=-8.000000e-04        pk2we=0.000000e+00        lk2we=0.000000e+00
+ wk2we=0.000000e+00        rshg=8.41                 minr=1e-3
     2: type=p 
+ lmin=1.2e-006-dxlp_5      lmax=1e-005-dxlp_5        wmin=1e-005-dxwp_5
+ wmax=900.01e-6            version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.68643677+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-3.4032994e-008+dlvthp_5                      k1=0.97
+ k2=0.037589912+dk2p_5     lk2=-2.825278e-009+dlk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00077087551         lcit=1.7588443e-010       voff=-0.16210857
+ lvoff=-8.5017542e-009     nfactor=0.5               eta0=0.004
+ etab=-0.064227            ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.015573098+du0p_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=-9.6312795e-010+dlu0p_5
+ ua=2.3212415e-009         lua=1.8417087e-016        ub=1.7102818e-019
+ lub=-3.5385976e-025       uc=-6.5388182e-011        luc=1.3629169e-017
+ vsat=77212.885            lvsat=-0.0012347164+dlvsatp_5
+ kvsat=-2.550000e-01       a0=1.335466               la0=-4.433044e-007+dla0p_5
+ ags=0.11779379+dagsp_5    lags=2.1968563e-008       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.010439651          lketa=-1.636318e-008      dwg=0
+ dwb=0                     pclm=0.29921902+dpclmp_5  lpclm=7.9503486e-010
+ pdiblc1=0                 pdiblc2=0.00041408394+dpdiblc2p_5
+ lpdiblc2=6.4716383e-010   pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=203.55233
+ lalpha1=-0.00016251081    beta0=50.162421+dbeta0p_5 lbeta0=-8.2217962e-006
+ agidl=5.4998739e-012      lagidl=4.1562151e-018     bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5
+ cgdo=cgop_5               cgbo=0                    cgdl=cglp_5
+ cgsl=cglp_5               clc=1e-007                cle=0.6
+ cf=cfp_5                  ckappas=0.6               ckappad=0.6
+ acde=1                    moin=25                   noff=2
+ voffcv=-0.02              tvoff=0.00266682          ltvoff=-1.198e-009
+ wtvoff=0                  ptvoff=0                  kt1=-0.36590516
+ lkt1=-2.979609e-008       kt1l=0                    kt2=-0.052530002
+ lkt2=4.2225452e-009       ute=-1.2493324            lute=1.2402544e-007
+ ua1=-2.2264787e-010       lua1=1.4845981e-015       ub1=-9.2882155e-019
+ lub1=-3.25151e-024        uc1=6.5414186e-011        luc1=-9.2428482e-017
+ prt=0                     at=77193.524              lat=-0.070626018
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=1.67e+41             noib=1.612e+24
+ noic=3.5e9                lintnoi=-1e-7             jss=1.94e-07
+ jsd=1.94e-07              jsws=7.03e-14             jswd=7.03e-14
+ jswgs=8.1e-14             jswgd=8.1e-14             njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=8.4
+ bvd=8.4                   xjbvs=1                   xjbvd=1
+ jtsswgs=5.2e-010          jtsswgd=5.2e-010          njtsswg=30
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1.5
+ vtsswgs=19.9              vtsswgd=19.9              pbs=0.822
+ pbd=0.822                 cjs=cjp_5                 cjd=cjp_5
+ mjs=0.367                 mjd=0.367                 pbsws=0.767
+ pbswd=0.767               cjsws=cjswp_5             cjswd=cjswp_5
+ mjsws=0.275               mjswd=0.275               pbswgs=0.783
+ pbswgd=0.783              cjswgs=cjswgp_5           cjswgd=cjswgp_5
+ mjswgs=0.361              mjswgd=0.361              tpb=0.00165
+ tcj=0.000954              tpbsw=0.0016              tcjsw=0.0007
+ tpbswg=0.00187            tcjswg=0.00115            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthp_5          pvth0=0+dpvthp_5          wu0=0+dwu0p_5
+ pu0=0+dpu0p_5             wk2=0+dwk2p_5             pk2=0+dpk2p_5
+ pvsat=0+dpvsatp_5         pbeta0=0+dpbeta0p_5       wpclm=0+dwpclmp_5
+ wags=0+dwagsp_5           pat=0+dpatp_5             saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
     3: type=p 
+ lmin=6e-007-dxlp_5        lmax=1.2e-006-dxlp_5      wmin=1e-005-dxwp_5
+ wmax=900.01e-6            version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.72470853+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=4.9276601e-009+dlvthp_5                       k1=0.97
+ k2=0.033163468+dk2p_5     lk2=1.6808418e-009+dlk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00086774817         lcit=7.7268066e-011       voff=-0.16918644
+ lvoff=-1.2964865e-009     nfactor=0.5               eta0=0.004
+ etab=-0.064227            ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.015123723+du0p_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=-5.0566435e-010+dlu0p_5
+ ua=2.4059966e-009         lua=9.7890222e-017        ub=-1.384176e-019
+ lub=-3.8843955e-026       uc=-6.036e-011            luc=8.51048e-018
+ vsat=80180                lvsat=-0.00425524+dlvsatp_5
+ kvsat=-2.550000e-01       a0=1.1308057              la0=-2.3496017e-007+dla0p_5
+ ags=0.1668044+dagsp_5     lags=-2.792424e-008       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.0019224993        lketa=-3.7785113e-009     dwg=0
+ dwb=0                     pclm=0.21089633+dpclmp_5  lpclm=9.0707533e-008
+ pdiblc1=0                 pdiblc2=0.00041161147+dpdiblc2p_5
+ lpdiblc2=6.4968081e-010   pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=63.118617
+ lalpha1=-1.9549282e-005   beta0=45.924633+dbeta0p_5 lbeta0=-3.9077287e-006
+ agidl=8.7080047e-012      lagidl=8.9033805e-019     bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5
+ cgdo=cgop_5               cgbo=0                    cgdl=cglp_5
+ cgsl=cglp_5               clc=1e-007                cle=0.6
+ cf=cfp_5                  ckappas=0.6               ckappad=0.6
+ acde=1                    moin=25                   noff=2
+ voffcv=-0.02              tvoff=0.00107374          ltvoff=4.23756e-010
+ wtvoff=0                  ptvoff=0                  kt1=-0.38455128
+ lkt1=-1.0814332e-008      kt1l=0                    kt2=-0.052616898
+ lkt2=4.311005e-009        ute=-1.0629887            lute=-6.5672537e-008
+ ua1=1.682751e-009         lua1=-4.5509792e-016      ub1=-4.6838886e-018
+ lub1=5.7114826e-025       uc1=-4.30614e-011         luc1=1.7999665e-017
+ prt=0                     at=40489.97               lat=-0.0332618
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=1.67e+41             noib=1.612e+24
+ noic=3.5e9                lintnoi=-1e-7             jss=1.94e-07
+ jsd=1.94e-07              jsws=7.03e-14             jswd=7.03e-14
+ jswgs=8.1e-14             jswgd=8.1e-14             njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=8.4
+ bvd=8.4                   xjbvs=1                   xjbvd=1
+ jtsswgs=5.2e-010          jtsswgd=5.2e-010          njtsswg=30
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1.5
+ vtsswgs=19.9              vtsswgd=19.9              pbs=0.822
+ pbd=0.822                 cjs=cjp_5                 cjd=cjp_5
+ mjs=0.367                 mjd=0.367                 pbsws=0.767
+ pbswd=0.767               cjsws=cjswp_5             cjswd=cjswp_5
+ mjsws=0.275               mjswd=0.275               pbswgs=0.783
+ pbswgd=0.783              cjswgs=cjswgp_5           cjswgd=cjswgp_5
+ mjswgs=0.361              mjswgd=0.361              tpb=0.00165
+ tcj=0.000954              tpbsw=0.0016              tcjsw=0.0007
+ tpbswg=0.00187            tcjswg=0.00115            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthp_5          pvth0=0+dpvthp_5          wu0=0+dwu0p_5
+ pu0=0+dpu0p_5             wk2=0+dwk2p_5             pk2=0+dpk2p_5
+ pvsat=0+dpvsatp_5         pbeta0=0+dpbeta0p_5       wpclm=0+dwpclmp_5
+ wags=0+dwagsp_5           pat=0+dpatp_5             saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
     4: type=p 
+ lmin=5e-07                lmax=6e-007-dxlp_5        wmin=1e-005-dxwp_5
+ wmax=900.01e-6            version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.68600758+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-1.1249337e-008+dlvthp_5                      k1=0.97
+ k2=0.043825565+dk2p_5     lk2=-2.7759144e-009+dlk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00091191034         lcit=5.8808276e-011       voff=-0.2217071
+ lvoff=2.0657149e-008      nfactor=0.5               eta0=0.004
+ etab=-0.064227            ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.014076638+du0p_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=-6.7982651e-011+dlu0p_5
+ ua=2.2231664e-009         lua=1.7431325e-016        ub=-3.497941e-019
+ lub=4.9511422e-026        uc=-2.092e-011            luc=-7.97544e-018
+ vsat=70000                a0=1.0394028              la0=-1.9675375e-007+dla0p_5
+ kvsat=-2.550000e-01       ags=0.1+dagsp_5           a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.023550348         lketa=5.2619295e-009      dwg=0
+ dwb=0                     pclm=0.357622+dpclmp_5    lpclm=2.9376204e-008
+ pdiblc1=0                 pdiblc2=-0.0086196054+dpdiblc2p_5
+ lpdiblc2=4.4247295e-009   pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=36.9246
+ lalpha1=-8.6001828e-006   beta0=45.83298+dbeta0p_5  lbeta0=-3.8694176e-006
+ agidl=-2.392576e-011      lagidl=1.4531252e-017     bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5
+ cgdo=cgop_5               cgbo=0                    cgdl=cglp_5
+ cgsl=cglp_5               clc=1e-007                cle=0.6
+ cf=cfp_5                  ckappas=0.6               ckappad=0.6
+ acde=1                    moin=25                   noff=2
+ voffcv=-0.02              tvoff=0.00352528          ltvoff=-6.00988e-010
+ wtvoff=0                  ptvoff=0                  kt1=-0.34984757
+ lkt1=-2.5320483e-008      kt1l=0                    kt2=-0.037840302
+ lkt2=-1.8656119e-009      ute=-1.192116             lute=-1.1697312e-008
+ ua1=3.24612e-009          lua1=-1.1085862e-015      ub1=-9.1361866e-018
+ lub1=2.4322088e-024       uc1=-2.23872e-010         luc1=9.3578496e-017
+ prt=0                     at=-43429.877             lat=0.0018166956
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=1.67e+41             noib=1.612e+24
+ noic=3.5e9                lintnoi=-1e-7             jss=1.94e-07
+ jsd=1.94e-07              jsws=7.03e-14             jswd=7.03e-14
+ jswgs=8.1e-14             jswgd=8.1e-14             njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=8.4
+ bvd=8.4                   xjbvs=1                   xjbvd=1
+ jtsswgs=5.2e-010          jtsswgd=5.2e-010          njtsswg=30
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1.5
+ vtsswgs=19.9              vtsswgd=19.9              pbs=0.822
+ pbd=0.822                 cjs=cjp_5                 cjd=cjp_5
+ mjs=0.367                 mjd=0.367                 pbsws=0.767
+ pbswd=0.767               cjsws=cjswp_5             cjswd=cjswp_5
+ mjsws=0.275               mjswd=0.275               pbswgs=0.783
+ pbswgd=0.783              cjswgs=cjswgp_5           cjswgd=cjswgp_5
+ mjswgs=0.361              mjswgd=0.361              tpb=0.00165
+ tcj=0.000954              tpbsw=0.0016              tcjsw=0.0007
+ tpbswg=0.00187            tcjswg=0.00115            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthp_5          pvth0=0+dpvthp_5          wu0=0+dwu0p_5
+ pu0=0+dpu0p_5             wk2=0+dwk2p_5             pk2=0+dpk2p_5
+ lvsat=0+dlvsatp_5         pvsat=0+dpvsatp_5         pbeta0=0+dpbeta0p_5
+ wpclm=0+dwpclmp_5         wags=0+dwagsp_5           pat=0+dpatp_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=1.700000e-06         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=6.000000e-09         lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        wec=0.000000e+00          web=0.000000e+00
+ kvth0we=-8.500000e-03     pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09
+ lkvth0we=1.000000e-09     ku0we=-2.500000e-03       pku0we=0.000000e+00
+ wku0we=1.000000e-09       lku0we=0.000000e+00       k2we=-8.000000e-04
+ pk2we=0.000000e+00        lk2we=0.000000e+00        wk2we=0.000000e+00
+ rshg=8.41                 minr=1e-3
     5: type=p 
+ lmin=1e-005-dxlp_5        lmax=900.01e-6            wmin=1.2e-006-dxwp_5
+ wmax=1e-005-dxwp_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.69390934+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ wvth0=4.0101933e-008+dwvthp_5                       k1=0.97
+ k2=0.03741499+dk2p_5      wk2=-1.1295619e-009+dwk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00080519238         wcit=-1.6418777e-010      voff=-0.16292975
+ wvoff=-4.4800043e-010     nfactor=0.5               eta0=0.004
+ etab=-0.065014738         wetab=7.8852524e-009      ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.015641513+du0p_5     ku0=7.500000e-08          tku0=0.000000e+00
+ pku0=1.000000e-13         wku0=1.000000e-06         lku0=1.000000e-07
+ wu0=-1.6667901e-009+dwu0p_5                         ua=2.3402613e-009
+ wua=-2.6151125e-018       ub=2.0185784e-019         wub=-6.6938469e-025
+ uc=-6.0635969e-011        wuc=-3.3673947e-017       vsat=77081.88
+ wvsat=5.2489437e-005      a0=1.301333               kvsat=-2.550000e-01
+ wa0=-1.1030231e-007       ags=0.12212476+dagsp_5    wags=-2.0954877e-008+dwagsp_5
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.0083760375         wketa=3.9735946e-009
+ dwg=0                     dwb=0                     pclm=0.2993+dpclmp_5
+ pdiblc1=0                 pdiblc2=0.00051064875+dpdiblc2p_5
+ wpdiblc2=-3.0679399e-010  pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=188.5675
+ walpha1=-1.5690675e-005   beta0=49.327338+dbeta0p_5 wbeta0=-2.3398375e-008
+ agidl=5.9987837e-012      wagidl=-7.5659334e-019    bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5
+ cgdo=cgop_5               cgbo=0                    cgdl=cglp_5
+ cgsl=cglp_5               clc=1e-007                cle=0.6
+ cf=cfp_5                  ckappas=0.6               ckappad=0.6
+ acde=1                    moin=25                   noff=2
+ voffcv=-0.02              tvoff=0.00257091          ltvoff=0
+ wtvoff=-2.61374e-010      ptvoff=0                  kt1=-0.3683995
+ wkt1=-5.410365e-009       kt1l=0                    kt2=-0.050762676
+ wkt2=-1.338581e-008       ute=-1.229825             wute=-6.881875e-008
+ ua1=-9.366575e-012        wua1=-6.2131494e-016      ub1=-1.31775e-018
+ wub1=5.780775e-025        uc1=5.1730757e-011        wuc1=4.2735122e-017
+ prt=0                     at=70000                  fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lvth0=0+dlvthp_5
+ pvth0=0+dpvthp_5          lu0=0+dlu0p_5             pu0=0+dpu0p_5
+ lk2=0+dlk2p_5             pk2=0+dpk2p_5             lvsat=0+dlvsatp_5
+ pvsat=0+dpvsatp_5         pbeta0=0+dpbeta0p_5       wpclm=0+dwpclmp_5
+ la0=0+dla0p_5             pat=0+dpatp_5             saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
     6: type=p 
+ lmin=1.2e-006-dxlp_5      lmax=1e-005-dxlp_5        wmin=1.2e-006-dxwp_5
+ wmax=1e-005-dxwp_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.68971121+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-4.1217263e-008+dlvthp_5                      wvth0=3.2777168e-008+dwvthp_5
+ pvth0=7.1914534e-014+dpvthp_5                       k1=0.97
+ k2=0.037738795+dk2p_5     lk2=-3.1791121e-009+dlk2p_5
+ wk2=-1.4903156e-009+dwk2p_5                         pk2=3.5418794e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00078869021         lcit=1.6201831e-010       wcit=-1.7832506e-010
+ pcit=1.3879984e-016       voff=-0.16193509          lvoff=-9.7655842e-009
+ wvoff=-1.7365458e-009     pvoff=1.2650939e-014      nfactor=0.5
+ eta0=0.004                etab=-0.065014738         wetab=7.8852524e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.015746912+du0p_5     ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         lu0=-1.0348089e-009+dlu0p_5
+ wu0=-1.7398728e-009+dwu0p_5                         pu0=7.1752592e-016+dpu0p_5
+ ua=2.3261207e-009         lua=1.388319e-016         wua=-4.884073e-017
+ pua=4.5384312e-022        ub=2.3585763e-019         lub=-3.3380997e-025
+ wub=-6.4894281e-025       pub=-2.0069839e-031       uc=-6.2049654e-011
+ luc=1.3879556e-017        wuc=-3.3418663e-017       puc=-2.5063735e-024
+ vsat=77224.213            lvsat=-0.0013974218+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-0.00011339778      pvsat=1.6286807e-009+dpvsatp_5
+ a0=1.3496687              la0=-4.7455973e-007+dla0p_5
+ wa0=-1.4216887e-007       pa0=3.1286588e-013        ags=0.12033563+dagsp_5
+ lags=1.7565756e-008       wags=-2.5443786e-008+dwagsp_5
+ pags=4.4072105e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=0.0099759062
+ lketa=-1.5707511e-008     wketa=4.6420864e-009      pketa=-6.5632518e-015
+ dwg=0                     dwb=0                     pclm=0.30080965+dpclmp_5
+ lpclm=-1.4821721e-008     wpclm=-1.5922156e-008+dwpclmp_5
+ ppclm=1.5632373e-013      pdiblc1=0                 pdiblc2=0.00043820478+dpdiblc2p_5
+ lpdiblc2=7.1125491e-010   wpdiblc2=-2.4144955e-010  ppdiblc2=-6.4155169e-016
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=205.43126          lalpha1=-0.00016556841
+ walpha1=-1.8808074e-005   palpha1=3.0606623e-011    beta0=50.181317+dbeta0p_5
+ lbeta0=-8.3843667e-006    wbeta0=-1.8914802e-007    pbeta0=1.62733e-012+dpbeta0p_5
+ agidl=5.5795472e-012      lagidl=4.1160644e-018     wagidl=-7.975292e-019
+ pagidl=4.0190831e-025     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00270484          ltvoff=-1.31493e-009      wtvoff=-3.80588e-010
+ ptvoff=1.17045e-015       kt1=-0.36518645           lkt1=-3.154574e-008
+ wkt1=-7.1942316e-009      pkt1=1.7514003e-014       kt1l=0
+ kt2=-0.051165353          lkt2=3.9534766e-009       wkt2=-1.3660141e-008
+ pkt2=2.6933766e-015       ute=-1.2418355            lute=1.1791929e-007
+ wute=-7.5044313e-008      pute=6.1122578e-014       ua1=-1.7142151e-010
+ lua1=1.5910554e-015       wua1=-5.1277583e-016      pua1=-1.065637e-021
+ ub1=-9.6118651e-019       lub1=-3.5007403e-024      wub1=3.2397326e-025
+ pub1=2.4947955e-030       uc1=6.194552e-011         luc1=-1.0028855e-016
+ wuc1=3.4721348e-017       puc1=7.8679234e-023       prt=0
+ at=77144.435              lat=-0.070144066          wat=0.00049137779
+ pat=-4.8243471e-009+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
     7: type=p 
+ lmin=6e-007-dxlp_5        lmax=1.2e-006-dxlp_5      wmin=1.2e-006-dxwp_5
+ wmax=1e-005-dxwp_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.73338006+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=3.2376215e-009+dlvthp_5                       wvth0=8.680197e-008+dwvthp_5
+ pvth0=1.6917286e-014+dpvthp_5                       k1=0.97
+ k2=0.033023784+dk2p_5     lk2=1.6207693e-009+dlk2p_5
+ wk2=1.3982444e-009+dwk2p_5                          pk2=6.0132539e-016+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00087648244         lcit=7.2645812e-011       wcit=-8.7430093e-011
+ pcit=4.6268767e-017       voff=-0.17005665          lvoff=-1.4978365e-009
+ wvoff=8.7108268e-009      pvoff=2.0155134e-015      nfactor=0.5
+ eta0=0.004                etab=-0.065014738         wetab=7.8852524e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.015172993+du0p_5     ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         lu0=-4.5056006e-010+dlu0p_5
+ wu0=-4.9319315e-010+dwu0p_5                         pu0=-5.5159399e-016+dpu0p_5
+ ua=2.3582765e-009         lua=1.0609733e-016        wua=4.7767817e-016
+ pua=-8.2153124e-023       ub=-4.8786089e-020        lub=-4.4042657e-026
+ wub=-8.9721138e-025       pub=5.2039011e-032        uc=-5.6176527e-011
+ luc=7.900713e-018         wuc=-4.1876563e-017       puc=6.1037679e-024
+ vsat=80502.795            lvsat=-0.0047350183+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-0.003231178        pvsat=4.8025809e-009+dpvsatp_5
+ a0=1.1105985              la0=-2.311863e-007+dla0p_5
+ wa0=2.0227345e-007        pa0=-3.7776398e-014       ags=0.16722155+dagsp_5
+ lags=-3.0164116e-008      wags=-4.1756698e-009+dwagsp_5
+ pags=2.2421163e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.0023568153
+ lketa=-3.1528004e-009     wketa=4.3475029e-009      pketa=-6.2633659e-015
+ dwg=0                     dwb=0                     pclm=0.18489458+dpclmp_5
+ lpclm=1.0317982e-007      wpclm=2.6027756e-007+dwpclmp_5
+ ppclm=-1.2484758e-013     pdiblc1=0                 pdiblc2=0.00057881854+dpdiblc2p_5
+ lpdiblc2=5.681101e-010    wpdiblc2=-1.6737428e-009  ppdiblc2=8.165228e-016
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=60.902075          lalpha1=-1.8437698e-005
+ walpha1=2.2187582e-005    palpha1=-1.1126955e-011   beta0=45.596656+dbeta0p_5
+ lbeta0=-3.7171826e-006    wbeta0=3.2830489e-006     pbeta0=-1.9073665e-012+dpbeta0p_5
+ agidl=8.7334469e-012      lagidl=9.0539451e-019     wagidl=-2.5467709e-019
+ pagidl=-1.5071514e-025    bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.000925054         ltvoff=4.96893e-010       wtvoff=1.48832e-009
+ ptvoff=-7.32099e-016      kt1=-0.38666979           lkt1=-9.6757057e-009
+ wkt1=2.1206214e-008       pkt1=-1.1397651e-014      kt1l=0
+ kt2=-0.051445371          lkt2=4.2385359e-009       wkt2=-1.1726977e-008
+ pkt2=7.2541559e-016       ute=-1.0710499            lute=-5.5940449e-008
+ wute=8.0693196e-008       pute=-9.7418206e-014      ua1=1.8170269e-009
+ lua1=-4.3318512e-016      wua1=-1.3441018e-015      pua1=-2.1934714e-022
+ ub1=-5.0323868e-018       lub1=6.4374163e-025       wub1=3.4884675e-024
+ pub1=-7.2665972e-031      uc1=-5.7448676e-011       luc1=2.1254747e-017
+ wuc1=1.4401663e-016       puc1=-3.2583364e-023      prt=0
+ at=40295.472              lat=-0.032631821          wat=0.0019469237
+ pat=-6.3060929e-009+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
     8: type=p 
+ lmin=5e-07                lmax=6e-007-dxlp_5        wmin=1.2e-006-dxwp_5
+ wmax=1e-005-dxwp_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.69639476+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-1.222223e-008+dlvthp_5                       wvth0=1.0397571e-007+dwvthp_5
+ pvth0=9.7386611e-015+dpvthp_5                       k1=0.97
+ k2=0.042619626+dk2p_5     lk2=-2.3902928e-009+dlk2p_5
+ wk2=1.2071443e-008+dwk2p_5                          pk2=-3.8600716e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00085535359         lcit=8.1477672e-011       wcit=5.6613312e-010
+ pcit=-2.2692065e-016      voff=-0.22952122          lvoff=2.3358355e-008
+ wvoff=7.8219421e-008      pvoff=-2.7039079e-014     nfactor=0.5
+ eta0=0.004                etab=-0.065014738         wetab=7.8852524e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.014152714+du0p_5     ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         lu0=-2.4083479e-011+dlu0p_5
+ wu0=-7.6152636e-010+dwu0p_5                         pu0=-4.394307e-016+dpu0p_5
+ ua=2.1532872e-009         lua=1.9178284e-016        wua=6.9949039e-016
+ pua=-1.7487063e-022       ub=-2.4873725e-019        lub=3.9536928e-026
+ wub=-1.011579e-024        pub=9.9844691e-032        uc=-2.1187839e-011
+ luc=-6.7245587e-018       wuc=2.6810684e-018        puc=-1.2521322e-023
+ vsat=67503.83             lvsat=0.00069854885+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=0.024986657         pvsat=-6.992474e-009+dpvsatp_5
+ a0=0.98363314             la0=-1.7811477e-007+dla0p_5
+ wa0=5.582539e-007         pa0=-1.8657623e-013       ags=0.079344922+dagsp_5
+ lags=6.5683148e-009       wags=2.0675733e-007+dwagsp_5
+ pags=-6.5748832e-014      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.022717129
+ lketa=5.3578109e-009      wketa=-8.3405187e-009     pketa=-9.5977286e-016
+ dwg=0                     dwb=0                     pclm=0.35179502+dpclmp_5
+ lpclm=3.3415432e-008      wpclm=5.832802e-008+dwpclmp_5
+ ppclm=-4.0432673e-014     pdiblc1=0                 pdiblc2=-0.0086259337+dpdiblc2p_5
+ lpdiblc2=4.4156965e-009   wpdiblc2=6.3346486e-011   ppdiblc2=9.0419495e-017
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=37.537878          lalpha1=-8.6714633e-006
+ walpha1=-6.1389078e-006   palpha1=7.1351776e-013    beta0=45.720368+dbeta0p_5
+ lbeta0=-3.7688939e-006    wbeta0=1.1272511e-006     pbeta0=-1.006243e-012+dpbeta0p_5
+ agidl=-2.4652597e-011     lagidl=1.4860761e-017     wagidl=7.2756365e-018
+ pagidl=-3.2983862e-024    bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00348618          ltvoff=-5.7366e-010       wtvoff=3.91326e-010
+ ptvoff=-2.73556e-016      kt1=-0.34536277           lkt1=-2.6942039e-008
+ wkt1=-4.48929e-008        pkt1=1.6231779e-014       kt1l=0
+ kt2=-0.034378684          lkt2=-2.8953397e-009      wkt2=-3.4650803e-008
+ pkt2=1.0307575e-014       ute=-1.1643019            lute=-1.6961102e-008
+ wute=-2.7841864e-007      pute=5.2690542e-014       ua1=3.9247732e-009
+ lua1=-1.3142231e-015      wua1=-6.7933188e-015      pua1=2.0584255e-021
+ ub1=-1.031542e-017        lub1=2.8520495e-024       wub1=1.1804126e-023
+ pub1=-4.2026051e-030      uc1=-2.647524e-010        luc1=1.079077e-016
+ wuc1=4.092128e-016        puc1=-1.4343536e-022      prt=0
+ at=-41941.756             lat=0.0017433404          wat=-0.014896085
+ pat=7.3428478e-010+dpatp_5                          fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
     9: type=p 
+ lmin=1e-005-dxlp_5        lmax=900.01e-6            wmin=5e-007-dxwp_5
+ wmax=1.2e-006-dxwp_5      version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.66249378+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ wvth0=2.0891039e-009+dwvthp_5                       k1=0.97
+ k2=0.041827672+dk2p_5     wk2=-6.4689064e-009+dwk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00067803157         wcit=-1.0323201e-011      voff=-0.16435748
+ wvoff=1.2795516e-009      nfactor=0.5               eta0=0.004
+ etab=-0.036925729         wetab=-2.6102448e-008     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.015851557+du0p_5     ku0=7.500000e-08          tku0=0.000000e+00
+ pku0=1.000000e-13         wku0=1.000000e-06         lku0=1.000000e-07
+ wu0=-1.9209441e-009+dwu0p_5                         ua=2.7971729e-009
+ wua=-5.5547816e-016       ub=-4.2843271e-019        wub=9.3266878e-026
+ uc=-7.6455671e-011        wuc=-1.4532108e-017       vsat=77945.092
+ wvsat=-0.00099199707      a0=1.2540152              kvsat=-2.550000e-01
+ wa0=-5.304775e-008        ags=0.11212959+dagsp_5    wags=-8.8607187e-009+dwagsp_5
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.0099246886         wketa=2.0997268e-009
+ dwg=0                     dwb=0                     pclm=0.29879+dpclmp_5
+ wpclm=6.171e-010+dwpclmp_5                          pdiblc1=0
+ pdiblc2=0.00034439999+dpdiblc2p_5                   wpdiblc2=-1.0563299e-010
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=107.91571          walpha1=8.1897986e-005
+ beta0=47.37+dbeta0p_5     wbeta0=2.34498e-006       agidl=-1.9584243e-011
+ wagidl=3.0198869e-017     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00232204          ltvoff=0                  wtvoff=3.97589e-011
+ ptvoff=0                  kt1=-0.37354181           wkt1=8.118215e-010
+ kt1l=0                    kt2=-0.054391374          wkt2=-8.9950863e-009
+ ute=-1.2260829            wute=-7.3346743e-008      ua1=-2.2534514e-010
+ wua1=-3.5998088e-016      ub1=-1.1897143e-018       wub1=4.2315429e-025
+ uc1=8.3441912e-011        wuc1=4.3646249e-018       prt=0
+ at=70000                  fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.13                   noia=1.67e+41
+ noib=1.612e+24            noic=3.5e9                lintnoi=-1e-7
+ jss=1.94e-07              jsd=1.94e-07              jsws=7.03e-14
+ jswd=7.03e-14             jswgs=8.1e-14             jswgd=8.1e-14
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.4                   bvd=8.4                   xjbvs=1
+ xjbvd=1                   jtsswgs=5.2e-010          jtsswgd=5.2e-010
+ njtsswg=30                xtsswgs=0.48              xtsswgd=0.48
+ tnjtsswg=1.5              vtsswgs=19.9              vtsswgd=19.9
+ pbs=0.822                 pbd=0.822                 cjs=cjp_5
+ cjd=cjp_5                 mjs=0.367                 mjd=0.367
+ pbsws=0.767               pbswd=0.767               cjsws=cjswp_5
+ cjswd=cjswp_5             mjsws=0.275               mjswd=0.275
+ pbswgs=0.783              pbswgd=0.783              cjswgs=cjswgp_5
+ cjswgd=cjswgp_5           mjswgs=0.361              mjswgd=0.361
+ tpb=0.00165               tcj=0.000954              tpbsw=0.0016
+ tcjsw=0.0007              tpbswg=0.00187            tcjswg=0.00115
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthp_5          pvth0=0+dpvthp_5
+ lu0=0+dlu0p_5             pu0=0+dpu0p_5             lk2=0+dlk2p_5
+ pk2=0+dpk2p_5             lvsat=0+dlvsatp_5         pvsat=0+dpvsatp_5
+ pbeta0=0+dpbeta0p_5       la0=0+dla0p_5             pat=0+dpatp_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=1.700000e-06         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=6.000000e-09         lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        wec=0.000000e+00          web=0.000000e+00
+ kvth0we=-8.500000e-03     pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09
+ lkvth0we=1.000000e-09     ku0we=-2.500000e-03       pku0we=0.000000e+00
+ wku0we=1.000000e-09       lku0we=0.000000e+00       k2we=-8.000000e-04
+ pk2we=0.000000e+00        lk2we=0.000000e+00        wk2we=0.000000e+00
+ rshg=8.41                 minr=1e-3
     10: type=p 
+ lmin=1.2e-006-dxlp_5      lmax=1e-005-dxlp_5        wmin=5e-007-dxwp_5
+ wmax=1.2e-006-dxwp_5      version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.66220918+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-2.7942352e-009+dlvthp_5                      wvth0=-5.0029013e-010+dwvthp_5
+ pvth0=2.542267e-014+dpvthp_5                        k1=0.97
+ k2=0.041763423+dk2p_5     lk2=6.3079327e-010+dlk2p_5
+ wk2=-6.3601158e-009+dwk2p_5                         pk2=-1.0681061e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00064347909         lcit=3.3923622e-010       wcit=-2.6196128e-012
+ pcit=-7.5633833e-017      voff=-0.16323479          lvoff=-1.1022545e-008
+ wvoff=-1.6390547e-010     pvoff=1.4171861e-014      nfactor=0.5
+ eta0=0.004                etab=-0.036925729         wetab=-2.6102448e-008
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.015927826+du0p_5     ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         lu0=-7.4880927e-010+dlu0p_5
+ wu0=-1.9587794e-009+dwu0p_5                         pu0=3.7146641e-016+dpu0p_5
+ ua=2.7472564e-009         lua=4.9008003e-016        wua=-5.5841489e-016
+ pua=2.8832882e-023        ub=-3.5584932e-019        lub=-7.1262375e-025
+ wub=6.7022604e-026        pub=2.5766629e-031        uc=-7.8216048e-011
+ luc=1.7283376e-017        wuc=-1.3857327e-017       puc=-6.6249958e-024
+ vsat=78028.807            lvsat=-0.00082191593+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-0.0010869572       pvsat=9.3231861e-010+dpvsatp_5
+ a0=1.2954145              la0=-4.0645855e-007+dla0p_5
+ wa0=-7.6521313e-008       pa0=2.3046345e-013        ags=0.10958885+dagsp_5
+ lags=2.4945027e-008       wags=-1.2440184e-008+dwagsp_5
+ pags=3.5143188e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=0.011809559
+ lketa=-1.8505662e-008     wketa=2.423366e-009       pketa=-3.1774896e-015
+ dwg=0                     dwb=0                     pclm=0.28371054+dpclmp_5
+ lpclm=1.4805009e-007      wpclm=4.7677587e-009+dwpclmp_5
+ ppclm=-4.0751167e-014     pdiblc1=0                 pdiblc2=0.00030938286+dpdiblc2p_5
+ lpdiblc2=3.4379823e-010   wpdiblc2=-8.5575028e-011  ppdiblc2=-1.9692911e-016
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=117.89678          lalpha1=-9.7994148e-005
+ walpha1=8.7108643e-005    palpha1=-5.1158234e-011   beta0=48.24452+dbeta0p_5
+ lbeta0=-8.5860358e-006    wbeta0=2.154376e-006      pbeta0=1.8713497e-012+dpbeta0p_5
+ agidl=-2.0676908e-011     lagidl=1.0727779e-017     wagidl=3.0972781e-017
+ pagidl=-7.5982663e-024    bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00241638          ltvoff=-9.26264e-010      wtvoff=-3.15551e-011
+ ptvoff=7.0016e-016        kt1=-0.37156939           lkt1=-1.9365164e-008
+ wkt1=5.2912585e-010       pkt1=2.7755059e-015       kt1l=0
+ kt2=-0.054794214          lkt2=3.9550838e-009       wkt2=-9.2692187e-009
+ pkt2=2.6914318e-015       ute=-1.2433986            lute=1.7000604e-007
+ wute=-7.3152978e-008      pute=-1.9023886e-015      ua1=-2.5391359e-010
+ lua1=2.8048505e-016       wua1=-4.1296042e-016      pua1=5.201531e-022
+ ub1=-1.1336784e-018       lub1=-5.5016005e-025      wub1=5.3268847e-025
+ pub1=-1.0754066e-030      uc1=8.5267923e-011        luc1=-1.7927774e-017
+ wuc1=6.5012412e-018       puc1=-2.0977299e-023      prt=0
+ at=76445.946              lat=-0.063286294          wat=0.0013365503
+ pat=-1.3122251e-008+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
     11: type=p 
+ lmin=6e-007-dxlp_5        lmax=1.2e-006-dxlp_5      wmin=5e-007-dxwp_5
+ wmax=1.2e-006-dxwp_5      version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.66070827+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-4.3221625e-009+dlvthp_5                      wvth0=-1.1308937e-009+dwvthp_5
+ pvth0=2.6064625e-014+dpvthp_5                       k1=0.97
+ k2=0.037832258+dk2p_5     lk2=4.6327196e-009+dlk2p_5
+ wk2=-4.4200094e-009+dwk2p_5                         pk2=-3.0431344e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00083765343         lcit=1.4156674e-010       wcit=-4.0446993e-011
+ pcit=-3.712556e-017       voff=-0.15683263          lvoff=-1.7539949e-008
+ wvoff=-7.2902399e-009     pvoff=2.1426469e-014      nfactor=0.5
+ eta0=0.004                etab=-0.036925729         wetab=-2.6102448e-008
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.016472021+du0p_5     ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         lu0=-1.3027997e-009+dlu0p_5
+ wu0=-2.0650167e-009+dwu0p_5                         pu0=4.7961595e-016+dpu0p_5
+ ua=3.437413e-009          lua=-2.1249938e-016       wua=-8.2807698e-016
+ pua=3.0334889e-022        ub=-1.2907724e-018        lub=2.3912799e-025
+ wub=6.0559211e-025        pub=-2.9059748e-031       uc=-9.1761656e-011
+ luc=3.1072806e-017        wuc=1.1814438e-018        puc=-2.1934465e-023
+ vsat=79769.669            lvsat=-0.002594113+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-0.0023440955       pvsat=2.2120854e-009+dpvsatp_5
+ a0=1.341711               la0=-4.5358832e-007+dla0p_5
+ wa0=-7.7372586e-008       pa0=2.3133004e-013        ags=0.19337448+dagsp_5
+ lags=-6.0348748e-008      wags=-3.5820714e-008+dwagsp_5
+ pags=5.8944568e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=0.0063616752
+ lketa=-1.2959715e-008     wketa=-6.2018706e-009     pketa=5.6030012e-015
+ dwg=0                     dwb=0                     pclm=0.4955391+dpclmp_5
+ lpclm=-6.7591376e-008     wpclm=-1.1560231e-007+dwpclmp_5
+ ppclm=8.1785565e-014      pdiblc1=0                 pdiblc2=-0.0013027447+dpdiblc2p_5
+ lpdiblc2=1.9849441e-009   wpdiblc2=6.0294871e-010   ppdiblc2=-8.9784628e-016
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=45.582055          lalpha1=-2.4377753e-005
+ walpha1=4.0724806e-005    palpha1=-3.9394881e-012   beta0=47.433874+dbeta0p_5
+ lbeta0=-7.7607979e-006    wbeta0=1.0600162e-006     pbeta0=2.985408e-012+dpbeta0p_5
+ agidl=-9.6020361e-012     lagidl=-5.4644023e-019    wagidl=2.1931257e-017
+ pagidl=1.6060049e-024     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00221535          ltvoff=-7.21607e-010      wtvoff=-7.29357e-011
+ ptvoff=7.42286e-016       kt1=-0.37513789           lkt1=-1.5732436e-008
+ wkt1=7.2526162e-009       pkt1=-4.0690073e-015      kt1l=0
+ kt2=-0.055181009          lkt2=4.3488418e-009       wkt2=-7.2068549e-009
+ pkt2=5.9194545e-016       ute=-0.9124255            lute=-1.6692459e-007
+ wute=-1.1124236e-007      pute=3.6872602e-014       ua1=4.690294e-010
+ lua1=-4.5547091e-016      wua1=2.8697518e-016       pua1=-1.9238133e-022
+ ub1=-9.3562626e-019       lub1=-7.5177717e-025      wub1=-1.4686128e-024
+ pub1=9.6191803e-031       uc1=1.0368476e-010        luc1=-3.6676116e-017
+ wuc1=-5.0954829e-017      puc1=3.751298e-023        prt=0
+ at=49027.864              lat=-0.035374688          wat=-0.0086192712
+ pat=-2.9872243e-009+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
     12: type=p 
+ lmin=5e-07                lmax=6e-007-dxlp_5        wmin=5e-007-dxwp_5
+ wmax=1.2e-006-dxwp_5      version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.60824653+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-2.6251167e-008+dlvthp_5                      wvth0=-2.6836445e-009+dwvthp_5
+ pvth0=2.6713675e-014+dpvthp_5                       k1=0.97
+ k2=0.054494556+dk2p_5     lk2=-2.3321208e-009+dlk2p_5
+ wk2=-2.2972216e-009+dwk2p_5                         pk2=-3.9304597e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.0019219753          lcit=-3.1167981e-010      wcit=-7.2447919e-010
+ pcit=2.487999e-016        voff=-0.27053841          lvoff=2.9989068e-008
+ wvoff=1.2785022e-007      pvoff=-3.5062242e-014     nfactor=0.5
+ eta0=0.004                etab=-0.036925729         wetab=-2.6102448e-008
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.014296286+du0p_5     ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         lu0=-3.9334223e-010+dlu0p_5
+ wu0=-9.3524736e-010+dwu0p_5                         pu0=7.3723884e-018+dpu0p_5
+ ua=2.9612722e-009         lua=-1.3472551e-017       wua=-2.781715e-016
+ pua=7.3488395e-023        ub=-1.5053681e-018        lub=3.2882898e-025
+ wub=5.089443e-025         pub=-2.5019869e-031       uc=-7.0614526e-012
+ luc=-4.3318792e-018       wuc=-1.4411859e-017       puc=-1.5416464e-023
+ vsat=85666.646            lvsat=-0.0050590495+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=0.0030096496        pvsat=-2.578004e-011+dpvsatp_5
+ a0=0.31576077             la0=-2.4741144e-008+dla0p_5
+ wa0=1.3663795e-006        pa0=-3.7215832e-013       ags=0.0026607052+dagsp_5
+ lags=1.936961e-008        wags=2.9954523e-007+dwagsp_5
+ pags=-8.1238399e-014      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.024937442
+ lketa=1.2331549e-010      wketa=-5.6539407e-009     pketa=5.3739665e-015
+ dwg=0                     dwb=0                     pclm=0.3551254+dpclmp_5
+ lpclm=-8.8984476e-009     wpclm=5.429827e-008+dwpclmp_5
+ ppclm=1.0767122e-014      pdiblc1=0                 pdiblc2=-0.0048624848+dpdiblc2p_5
+ lpdiblc2=3.4729154e-009   wpdiblc2=-4.4904267e-009  ppdiblc2=1.2311846e-015
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=-64.563479         lalpha1=2.166308e-005
+ walpha1=0.00011740373     palpha1=-3.599128e-011    beta0=31.794471+dbeta0p_5
+ lbeta0=-1.2235274e-006    wbeta0=1.7977586e-005     pbeta0=-4.0861364e-012+dpbeta0p_5
+ agidl=-6.0226064e-011     lagidl=2.0614403e-017     wagidl=5.0319531e-017
+ pagidl=-1.0260294e-023    bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.000159353         ltvoff=1.37798e-010       wtvoff=4.41679e-009
+ ptvoff=-1.13442e-015      kt1=-0.39750811           lkt1=-6.3816843e-009
+ wkt1=1.8202959e-008       pkt1=-8.6462505e-015      kt1l=0
+ kt2=-0.053757626          lkt2=3.7538673e-009       wkt2=-1.1202284e-008
+ pkt2=2.2620347e-015       ute=-1.601204             lute=1.2098483e-007
+ wute=2.5023285e-007       pute=-1.1422403e-013      ua1=-3.2609486e-009
+ lua1=1.1036599e-015       wua1=1.9014047e-015       pua1=-8.6721287e-022
+ ub1=4.07848e-019          lub1=-1.3133494e-024      wub1=-1.1710279e-024
+ pub1=8.3752756e-031       uc1=1.0625486e-010        luc1=-3.7750416e-017
+ wuc1=-3.9705977e-017      puc1=3.281096e-023        prt=0
+ at=-19400.611             lat=-0.0067715849         wat=-0.042170871
+ pat=1.1037344e-008+dpatp_5                          fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
     13: type=p 
+ lmin=1e-005-dxlp_5        lmax=900.01e-6            wmin=2.2e-07
+ wmax=5e-007-dxwp_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.66212202+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ wvth0=1.8995051e-009+dwvthp_5                       k1=0.97
+ k2=0.046774013+dk2p_5     wk2=-8.9915406e-009+dwk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00049508143         wcit=8.2981371e-011       voff=-0.16598187
+ wvoff=2.1079916e-009      nfactor=0.5               eta0=0.004
+ etab=-0.097371071         wetab=4.7246764e-009      ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.0131315+du0p_5       wu0=-5.33715e-010+dwu0p_5 ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         ua=2.3283196e-009         wua=-3.1636298e-016
+ ub=-3.9613231e-019        wub=7.679367e-026         uc=-8.2809732e-011
+ wuc=-1.1291537e-017       vsat=76000                a0=1.2203421
+ wa0=-3.5874445e-008       kvsat=-2.550000e-01       ags=0.11509062+dagsp_5
+ wags=-1.0370842e-008+dwagsp_5                       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.0093734571         wketa=2.3808549e-009      dwg=0
+ dwb=0                     pclm=0.38214286+dpclmp_5  wpclm=-4.1892857e-008+dwpclmp_5
+ pdiblc1=0                 pdiblc2=8.724068e-005+dpdiblc2p_5
+ wpdiblc2=2.5518256e-011   pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=348.25729
+ walpha1=-4.0676216e-005   beta0=54.458571+dbeta0p_5 wbeta0=-1.2701914e-006
+ agidl=2.1645055e-011      wagidl=9.1719275e-018     bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5
+ cgdo=cgop_5               cgbo=0                    cgdl=cglp_5
+ cgsl=cglp_5               clc=1e-007                cle=0.6
+ cf=cfp_5                  ckappas=0.6               ckappad=0.6
+ acde=1                    moin=25                   noff=2
+ voffcv=-0.02              tvoff=0.00125616          ltvoff=0
+ wtvoff=5.83358e-010       ptvoff=0                  kt1=-0.4051201
+ wkt1=1.6916748e-008       kt1l=0                    kt2=-0.073438614
+ wkt2=7.1900618e-010       ute=-1.5631               wute=9.8532e-008
+ ua1=-1.8218157e-009       wua1=4.5421911e-016       ub1=-5.6818847e-019
+ wub1=1.0617612e-025       uc1=1.0185714e-010        wuc1=-5.0271429e-018
+ prt=0                     at=70000                  fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lvth0=0+dlvthp_5
+ pvth0=0+dpvthp_5          lu0=0+dlu0p_5             pu0=0+dpu0p_5
+ lk2=0+dlk2p_5             pk2=0+dpk2p_5             lvsat=0+dlvsatp_5
+ pvsat=0+dpvsatp_5         pbeta0=0+dpbeta0p_5       la0=0+dla0p_5
+ pat=0+dpatp_5             saref=1.000000e-05        sbref=1.000000e-05
+ llodvth=1.000000e+00      wlodvth=1.000000e+00      wlod=1.700000e-06
+ steta0=0.000000e+00       lodeta0=1.000000e+00      stk2=6.000000e-09
+ lodk2=1.000000e+00        llodku0=1.000000e+00      wlodku0=1.000000e+00
+ wpemod=1.000000e+00       scref=1.000000e-06        wec=0.000000e+00
+ web=0.000000e+00          kvth0we=-8.500000e-03     pkvth0we=0.000000e+00
+ wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09     ku0we=-2.500000e-03
+ pku0we=0.000000e+00       wku0we=1.000000e-09       lku0we=0.000000e+00
+ k2we=-8.000000e-04        pk2we=0.000000e+00        lk2we=0.000000e+00
+ wk2we=0.000000e+00        rshg=8.41                 minr=1e-3
     14: type=p 
+ lmin=1.2e-006-dxlp_5      lmax=1e-005-dxlp_5        wmin=2.2e-07
+ wmax=5e-007-dxwp_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.66479035+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=2.6197706e-008+dlvthp_5                       wvth0=8.161092e-010+dwvthp_5
+ pvth0=1.0636781e-014+dpvthp_5                       k1=0.97
+ k2=0.046617135+dk2p_5     lk2=1.5402364e-009+dlk2p_5
+ wk2=-8.8355086e-009+dwk2p_5                         pk2=-1.5319221e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00045209576         lcit=4.2203334e-010       wcit=9.498589e-011
+ pcit=-1.1786036e-016      voff=-0.1649987           lvoff=-9.6528132e-009
+ wvoff=7.3568584e-010      pvoff=1.3473298e-014      nfactor=0.5
+ eta0=0.004                etab=-0.097371071         wetab=4.7246764e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.013087815+du0p_5     ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         lu0=4.2889997e-010+dlu0p_5
+ wu0=-5.1037366e-010+dwu0p_5                         pu0=-2.291653e-016+dpu0p_5
+ ua=2.2873169e-009         lua=4.0256436e-016        wua=-3.2384575e-016
+ pua=7.3465874e-023        ub=-3.7425258e-019        lub=-2.1481512e-025
+ wub=7.6408267e-026        pub=3.7838883e-033        uc=-8.4525724e-011
+ luc=1.6847613e-017        wuc=-1.0639392e-017       puc=-6.4027568e-024
+ vsat=76003.387            lvsat=-3.324998e-005+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-5.3992562e-005     pvsat=5.3009898e-010+dpvsatp_5
+ a0=1.2580608              la0=-3.7032308e-007+dla0p_5
+ wa0=-5.7470937e-008       pa0=2.1203436e-013        ags=0.10823775+dagsp_5
+ lags=6.7281399e-008       wags=-1.1751127e-008+dwagsp_5
+ pags=1.3551638e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=0.012424338
+ lketa=-2.9953551e-008     wketa=2.1098288e-009      pketa=2.660934e-015
+ dwg=0                     dwb=0                     pclm=0.3742517+dpclmp_5
+ lpclm=7.7475336e-008      wpclm=-4.1408233e-008+dwpclmp_5
+ ppclm=-4.7580403e-015     pdiblc1=0                 pdiblc2=8.5764659e-005+dpdiblc2p_5
+ lpdiblc2=1.4491577e-011   wpdiblc2=2.8470255e-011   ppdiblc2=-2.8982719e-017
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=378.26145          lalpha1=-0.00029458086
+ walpha1=-4.5677335e-005   palpha1=4.910099e-011     beta0=55.309333+dbeta0p_5
+ lbeta0=-8.3527742e-006    wbeta0=-1.4486785e-006    pbeta0=1.7523862e-012+dpbeta0p_5
+ agidl=2.2160064e-011      lagidl=-5.0563619e-018    wagidl=9.1259257e-018
+ pagidl=4.5164555e-025     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00119469          ltvoff=6.03567e-010       wtvoff=5.91512e-010
+ ptvoff=-8.00534e-017      kt1=-0.40598976           lkt1=8.5383829e-009
+ wkt1=1.8083514e-008       pkt1=-1.1455303e-014      kt1l=0
+ kt2=-0.074755392          lkt2=1.2928128e-008       wkt2=9.1098221e-010
+ pkt2=-1.8848206e-015      ute=-1.6000608            lute=3.6288112e-007
+ wute=1.0874474e-007       pute=-1.0026868e-013      ua1=-2.0149537e-009
+ lua1=1.8962287e-015       wua1=4.8517004e-016       pua1=-3.0387616e-022
+ ub1=-2.9233283e-019       lub1=-2.7083506e-024      wub1=1.0360222e-025
+ pub1=2.5270542e-032       uc1=1.1053328e-010        luc1=-8.5182307e-017
+ wuc1=-6.3840906e-018      puc1=1.3322513e-023       prt=0
+ at=76905.384              lat=-0.067797058          wat=0.0011022368
+ pat=-1.0821761e-008+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
     15: type=p 
+ lmin=6e-007-dxlp_5        lmax=1.2e-006-dxlp_5      wmin=2.2e-07
+ wmax=5e-007-dxwp_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.68601503+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=4.780443e-008+dlvthp_5                        wvth0=1.1775557e-008+dwvthp_5
+ pvth0=-5.1993714e-016+dpvthp_5                      k1=0.97
+ k2=0.053639668+dk2p_5     lk2=-5.6087022e-009+dlk2p_5
+ wk2=-1.2481788e-008+dwk2p_5                         pk2=2.1799907e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00074552869         lcit=1.2331861e-010       wcit=6.5366274e-012
+ pcit=-2.7819014e-017      voff=-0.21941137          lvoff=4.5739285e-008
+ wvoff=2.4624918e-008      pvoff=-1.084594e-014      nfactor=0.5
+ eta0=0.004                etab=-0.097371071         wetab=4.7246764e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.014132645+du0p_5     ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         lu0=-6.3473714e-010+dlu0p_5
+ wu0=-8.7193491e-010+dwu0p_5                         pu0=1.3890406e-016+dpu0p_5
+ ua=2.2671228e-009         lua=4.2312194e-016        wua=-2.31229e-016
+ pua=-2.0817983e-023       ub=-7.9871376e-020        lub=-5.1449519e-025
+ wub=-1.1967431e-026       pub=9.3750349e-032        uc=-6.031412e-011
+ luc=-7.7998002e-018       wuc=-1.48568e-017         puc=-2.1094355e-024
+ vsat=77632.475            lvsat=-0.0016916615+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-0.0012541264       pvsat=1.7518352e-009+dpvsatp_5
+ a0=1.1506591              la0=-2.6098805e-007+dla0p_5
+ wa0=2.0063886e-008        pa0=1.3310391e-013        ags=0.12077568+dagsp_5
+ lags=5.4517793e-008       wags=1.2046745e-009+dwagsp_5
+ pags=3.6263179e-016       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.01680243
+ lketa=-2.0070042e-010     wketa=5.6118233e-009      pketa=-9.040964e-016
+ dwg=0                     dwb=0                     pclm=0.42743201+dpclmp_5
+ lpclm=2.3337785e-008      wpclm=-8.0867696e-008+dwpclmp_5
+ ppclm=3.5411693e-014      pdiblc1=0                 pdiblc2=-0.00013112025+dpdiblc2p_5
+ lpdiblc2=2.3528041e-010   wpdiblc2=5.4202581e-012   ppdiblc2=-5.5178228e-018
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=139.98668          lalpha1=-5.2017143e-005
+ walpha1=-7.42155e-006     palpha1=1.0156601e-011    beta0=51.294675+dbeta0p_5
+ lbeta0=-4.2658528e-006    wbeta0=-9.0899261e-007    pbeta0=1.202986e-012+dpbeta0p_5
+ agidl=2.4298195e-011      lagidl=-7.2329796e-018    wagidl=4.6421394e-018
+ pagidl=5.01614e-024       bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.000379204         ltvoff=1.43373e-009       wtvoff=8.63497e-010
+ ptvoff=-3.56934e-016      kt1=-0.37071158           lkt1=-2.7374804e-008
+ wkt1=4.9952e-009          pkt1=1.8686003e-015       kt1l=0
+ kt2=-0.064173634          lkt2=2.1558985e-009       wkt2=-2.6206162e-009
+ pkt2=1.7103465e-015       ute=-1.0809083            lute=-1.6561616e-007
+ wute=-2.5316147e-008      pute=3.6205303e-014       ua1=1.0887407e-009
+ lua1=-1.2633322e-015      wua1=-2.9077612e-017      pua1=2.1962794e-022
+ ub1=-4.4849862e-018       lub1=1.5597705e-024       wub1=3.4156079e-025
+ pub1=-2.1697128e-031      uc1=-1.3781663e-011       luc1=4.1370305e-017
+ wuc1=8.9530482e-018       puc1=-2.2906945e-024      prt=0
+ at=50385.383              lat=-0.040799698          wat=-0.0093116061
+ pat=-2.2046888e-010+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
     16: type=p 
+ lmin=5e-07                lmax=6e-007-dxlp_5        wmin=2.2e-07
+ wmax=5e-007-dxwp_5        version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5
+ toxm=toxp_5               dtox=1.5777e-010          epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5          xw=1e-08+dxwp_5           dlc=6.33e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.69854491+dvthp_5  kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=5.3041919e-008+dlvthp_5                       wvth0=4.3368528e-008+dwvthp_5
+ pvth0=-1.3725799e-014+dpvthp_5                      k1=0.97
+ k2=0.079673196+dk2p_5     lk2=-1.6490717e-008+dlk2p_5
+ wk2=-1.5138328e-008+dwk2p_5                         pk2=3.2904244e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00075179781         lcit=1.2069812e-010       wcit=-1.2768866e-010
+ pcit=2.8287155e-017       voff=0.041196009          lvoff=-6.3194598e-008
+ wvoff=-3.1134336e-008     pvoff=1.2461428e-014      nfactor=0.5
+ eta0=0.004                etab=-0.097371071         wetab=4.7246764e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.013847383+du0p_5     ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         lu0=-5.1549758e-010+dlu0p_5
+ wu0=-7.0630706e-010+dwu0p_5                         pu0=6.9671616e-017+dpu0p_5
+ ua=2.6946966e-009         lua=2.4439609e-016        wua=-1.4221793e-016
+ pua=-5.802461e-023        ub=-7.8032085e-019        lub=-2.2170731e-025
+ wub=1.3917021e-025        pub=3.0574817e-032        uc=2.1311914e-011
+ luc=-4.1919482e-017       wuc=-2.8882276e-017       puc=3.7532136e-024
+ vsat=91249.476            lvsat=-0.0073835683+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=0.00016240623       pvsat=1.1597246e-009+dpvsatp_5
+ a0=2.5641989              la0=-8.5184773e-007+dla0p_5
+ wa0=2.19676e-007          pa0=4.9666041e-014        ags=0.70362741+dagsp_5
+ lags=-1.8911423e-007      wags=-5.7947785e-008+dwagsp_5
+ pags=2.508836e-014        a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.057760806
+ lketa=1.6919901e-008      wketa=1.1085975e-008      pketa=-3.1922919e-015
+ dwg=0                     dwb=0                     pclm=0.43004365+dpclmp_5
+ lpclm=2.2246119e-008      wpclm=1.608996e-008+dwpclmp_5
+ ppclm=-5.1166074e-015     pdiblc1=0                 pdiblc2=-0.015473916+dpdiblc2p_5
+ lpdiblc2=6.6485691e-009   wpdiblc2=9.2140327e-010   ppdiblc2=-3.8839872e-016
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=33.579801          lalpha1=-7.5390695e-006
+ walpha1=6.735066e-005     palpha1=-2.1098183e-011   beta0=53.200316+dbeta0p_5
+ lbeta0=-5.0624105e-006    wbeta0=7.0606054e-006     pbeta0=-2.128306e-012+dpbeta0p_5
+ agidl=1.6847523e-010      lagidl=-6.7498981e-017    wagidl=-6.6318129e-017
+ pagidl=3.4677532e-023     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.0103797           ltvoff=-2.74649e-009      wtvoff=-7.95592e-010
+ ptvoff=3.36565e-016       kt1=-0.39182241           lkt1=-1.8550479e-008
+ wkt1=1.5303251e-008       pkt1=-2.4401652e-015      kt1l=0
+ kt2=-0.082188619          lkt2=9.6861621e-009       wkt2=3.2975229e-009
+ pkt2=-7.6343561e-016      ute=-1.6119213            lute=5.6347279e-008
+ wute=2.5569865e-007       pute=-8.1258884e-014      ua1=-2.8396336e-009
+ lua1=3.7872824e-016       wua1=1.686534e-015        pua1=-4.9749772e-022
+ ub1=2.1147124e-018        lub1=-1.1989035e-024      wub1=-2.0415288e-024
+ pub1=7.7916016e-031       uc1=1.0442141e-010        luc1=-8.0385789e-018
+ wuc1=-3.8770918e-017      puc1=1.7657923e-023       prt=0
+ at=-112018.51             lat=0.027085129           wat=0.0050642572
+ pat=-6.2295797e-009+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.4                   bvd=8.4
+ xjbvs=1                   xjbvd=1                   jtsswgs=5.2e-010
+ jtsswgd=5.2e-010          njtsswg=30                xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1.5              vtsswgs=19.9
+ vtsswgd=19.9              pbs=0.822                 pbd=0.822
+ cjs=cjp_5                 cjd=cjp_5                 mjs=0.367
+ mjd=0.367                 pbsws=0.767               pbswd=0.767
+ cjsws=cjswp_5             cjswd=cjswp_5             mjsws=0.275
+ mjswd=0.275               pbswgs=0.783              pbswgd=0.783
+ cjswgs=cjswgp_5           cjswgd=cjswgp_5           mjswgs=0.361
+ mjswgd=0.361              tpb=0.00165               tcj=0.000954
+ tpbsw=0.0016              tcjsw=0.0007              tpbswg=0.00187
+ tcjswg=0.00115            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
 
     } 
endsection mos_5
// *********************************************************************************************
 

section mos_m
// *********************************************************************************************
//                                                                            
//                   *
//                               1.8 V MED-SVT  NMOS DEVICE MODELS            
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
 
// *********************************
//        Mismatch   model         * 
// *********************************
 
inline subckt mench_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2.05e-007 dmci=3.15e-007 
+ xw= + 0 + dxwnm ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf 
+ * dmcg + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor 
+ + (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 
+ 1) * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.00e-05 / factor sb=1.00e-05 / factor 
+ sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_m 
+ temp1=par1n_m temp2=par2n_m fac1=0.639217 * temp1 * sigma + 0.769027 * temp2 * 
+ sigma fac2=0.639217 * temp1 * sigma - 0.769027 * temp2 * sigma lef=l * factor 
+ - 1.5e-08 wef=w / nf * factor + 0 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) 
+ vthmisnm=0.00220296 * geo_fac * fac1 * mismatchflag dlmisnm=0.00162770 * geo_fac 
+ * lef * fac2 * mismatchflag dwmisnm= - 0.00162770 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisnm=0.00162770 * geo_fac * toxnm * fac2 * mismatchflag 
mench_mac ( n1 n2 n3 n4 ) mench w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model mench bsim4  { 
     1: type=n 
+ lmin=1e-005-(dxlnm+dlmisnm)                         lmax=2.001e-05
+ wmin=1.003e-005-(dxwnm+dwmisnm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.276+(dvthnm+vthmisnm)                        k1=0.4215
+ k2=0.021275+dk2m          k3=-2.2                   k3b=1.2
+ w0=0                      dvt0=0.2843               dvt1=0.1496
+ dvt2=-0.2039              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.684                minv=-0.112
+ voffl=-2.2e-009           dvtp0=0                   dvtp1=0
+ lpe0=9.17e-008            lpeb=0                    web=0
+ wec=0                     scref=1e-006              kvth0we=0.0024984743
+ lkvth0we=0                wkvth0we=0                pkvth0we=0
+ k2we=0.0043               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.5e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.0004+dcitnm        voff=-0.089+dvoffnm       nfactor=1
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.03968+du0nm          ua=-8.807e-010
+ ub=3.208e-018             uc=1.918e-010             vsat=88560+dvsatnm
+ a0=1.806+da0nm            ags=0.66052               a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.0674              dwg=0                     dwb=0
+ pclm=0.8351+dpclmnm       pdiblc1=0                 pdiblc2=0.000776+dpdiblc2nm
+ pdiblcb=0.55              drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.20623
+ kt1l=0                    kt2=-0.039870001          ute=-1.7599
+ ua1=5.3952e-010           ub1=-5.1533001e-019       uc1=-2.8145e-010
+ prt=0                     at=30388                  jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 lvth0=0+dlvthnm
+ wvth0=0+dwvthnm           pvth0=0+dpvthnm           lk2=0+dlk2m
+ lcit=0+dlcitnm            pcit=0+dpcitnm            lvoff=0+dlvoffnm
+ pvoff=0+dpvoffnm          lu0=0+dlu0nm              pu0=0+dpu0nm
+ lvsat=0+dlvsatnm          pvsat=0+dpvsatnm          la0=0+dla0nm
+ pa0=0+dpa0nm              lpclm=0+dlpclmnm          ppclm=0+dppclmnm
+ lpdiblc2=0+dlpdiblc2nm    ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     2: type=n 
+ lmin=1.2e-006-(dxlnm+dlmisnm)                       lmax=1e-005-(dxlnm+dlmisnm)
+ wmin=1.003e-005-(dxwnm+dwmisnm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.27419524+(dvthnm+vthmisnm)                   lvth0=1.7929235e-008+dlvthnm
+ k1=0.4215                 k2=0.021898286+dk2m       lk2=-6.1919893e-009+dlk2m
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0025032258      lkvth0we=-4.7203705e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00037421773+dcitnm
+ lcit=-2.5613193e-010+dlcitnm                        voff=-0.087710886+dvoffnm
+ lvoff=-1.2806596e-008+dlvoffnm                      nfactor=1
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.03968+du0nm          ua=-8.6739635e-010
+ lua=-1.3216407e-016       ub=3.1904552e-018         lub=1.7429778e-025
+ uc=1.918e-010             vsat=86543.826+dvsatnm    lvsat=0.020029517+dlvsatnm
+ a0=1.8640101+da0nm        la0=-5.7629683e-007+dla0nm
+ ags=0.64714416            lags=1.3288124e-007       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.066342927         lketa=-1.0501409e-008     dwg=0
+ dwb=0                     pclm=0.83712391+dpclmnm   lpclm=-2.0106356e-008+dlpclmnm
+ pdiblc1=0                 pdiblc2=0.00050956599+dpdiblc2nm
+ lpdiblc2=2.6468673e-009+dlpdiblc2nm                 pdiblcb=0.56289114
+ lpdiblcb=-1.2806595e-007  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.20141258
+ lkt1=-4.785825e-008       kt1l=0                    kt2=-0.039432992
+ lkt2=-4.3414349e-009      ute=-1.7475632            lute=-1.2255913e-007
+ ua1=4.7832835e-010        lua1=6.0790351e-016       ub1=-3.5875814e-019
+ lub1=-1.5554508e-024      uc1=-3.1257565e-010       luc1=3.0921527e-016
+ prt=0                     at=30388                  jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 wvth0=0+dwvthnm
+ pvth0=0+dpvthnm           pcit=0+dpcitnm            pvoff=0+dpvoffnm
+ lu0=0+dlu0nm              pu0=0+dpu0nm              pvsat=0+dpvsatnm
+ pa0=0+dpa0nm              ppclm=0+dppclmnm          ppdiblc2=0+dppdiblc2nm
+ leta0=0+dleta0nm          peta0=0+dpeta0nm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noian_m
+ noib=noibn_m              noic=noicn_m              em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     3: type=n 
+ lmin=5e-007-(dxlnm+dlmisnm)                         lmax=1.2e-006-(dxlnm+dlmisnm)
+ wmin=1.003e-005-(dxwnm+dwmisnm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.2924824+(dvthnm+vthmisnm)                    lvth0=-2.8160842e-009+dlvthnm
+ k1=0.4215                 k2=0.016713064+dk2m       lk2=-3.0976926e-010+dlk2m
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0025032258      lkvth0we=-4.7203626e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00078618+dcitnm
+ lcit=2.1120632e-010+dlcitnm                         voff=-0.10244433+dvoffnm
+ lvoff=3.9073168e-009+dlvoffnm                       nfactor=1
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.03968+du0nm          ua=-9.981738e-010
+ lua=1.6192484e-017        ub=3.2418872e-018         lub=1.1595227e-025
+ uc=1.8081538e-010         luc=1.2461173e-017        vsat=108358.02+dvsatnm
+ lvsat=-0.004716941+dlvsatnm                         a0=1.2653924+da0nm
+ la0=1.0278707e-007+dla0nm ags=0.90166843            lags=-1.5585618e-007
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.08466076          lketa=1.0278707e-008
+ dwg=0                     dwb=0                     pclm=0.73180852+dpclmnm
+ lpclm=9.9365531e-008+dlpclmnm                       pdiblc1=0
+ pdiblc2=0.0021294203+dpdiblc2nm                     lpdiblc2=8.092722e-010+dlpdiblc2nm
+ pdiblcb=0.79133002        lpdiblcb=-3.8721159e-007  drout=0.5
+ pvag=1.787                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=78.59                 rdw=78.59
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=1e-008              bgidl=2.2849e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgonm                cgdo=cgonm
+ cgbo=0                    cgdl=cglnm                cgsl=cglnm
+ clc=1e-007                cle=0.6                   cf=cfnm
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=1.586                voffcv=0.0135
+ kt1=-0.23664928           lkt1=-7.8850358e-009      kt1l=0
+ kt2=-0.047715908          lkt2=5.0548712e-009       ute=-1.82246
+ lute=-3.7594724e-008      ua1=1.0168065e-009        lua1=-2.9568884e-018
+ ub1=-1.7298379e-018       lub1=-7.0402105e-029      uc1=-3.672323e-011
+ luc1=-3.7172319e-018      prt=0                     at=30299.875
+ lat=9.9970989e-005        jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 wvth0=0+dwvthnm           pvth0=0+dpvthnm
+ pcit=0+dpcitnm            pvoff=0+dpvoffnm          lu0=0+dlu0nm
+ pu0=0+dpu0nm              pvsat=0+dpvsatnm          pa0=0+dpa0nm
+ ppclm=0+dppclmnm          ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     4: type=n 
+ lmin=2.85e-07             lmax=5e-007-(dxlnm+dlmisnm)
+ wmin=1.003e-005-(dxwnm+dwmisnm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.2918605+(dvthnm+vthmisnm)                    lvth0=-2.5459184e-009+dlvthnm
+ k1=0.4215                 k2=0.0034597021+dk2m      lk2=5.4477562e-009+dlk2m
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0025193604      lkvth0we=-5.4212838e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0003+dcitnm
+ voff=-0.10072991+dvoffnm  lvoff=3.1625398e-009+dlvoffnm
+ nfactor=1                 eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.041282261+du0nm
+ lu0=-6.9605409e-010+dlu0nm                          ua=-1.1847477e-009
+ lua=9.72439e-017          ub=4.3774433e-018         lub=-3.7735603e-025
+ uc=2.294257e-010          luc=-8.6561226e-018       vsat=114367.69+dvsatnm
+ lvsat=-0.0073276624+dlvsatnm                        a0=1.8412057+da0nm
+ la0=-1.4735776e-007+dla0nm                          ags=0.82232864
+ lags=-1.2138939e-007      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.082808093
+ lketa=9.4738716e-009      dwg=0                     dwb=0
+ pclm=0.76050941+dpclmnm   lpclm=8.6897287e-008+dlpclmnm
+ pdiblc1=0                 pdiblc2=0.00059637467+dpdiblc2nm
+ lpdiblc2=1.4752579e-009+dlpdiblc2nm                 pdiblcb=0.034614419
+ lpdiblcb=-5.8479196e-008  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.2752614
+ lkt1=8.8888399e-009       kt1l=0                    kt2=-0.041356886
+ lkt2=2.2923847e-009       ute=-2.2980357            lute=1.6900489e-007
+ ua1=-1.1699197e-010       lua1=4.8958785e-016       ub1=-3.9274033e-019
+ lub1=-5.8093235e-025      uc1=-4.6572299e-011       luc1=5.6140047e-019
+ prt=0                     at=31243.456              lat=-0.0003099396
+ jss=2.34e-07              jsd=2.34e-07              jsws=7.68e-13
+ jswd=7.68e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.3                  bvd=11.3                  xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjnm                  cjd=cjnm                  mjs=0.333
+ mjd=0.333                 pbsws=0.29                pbswd=0.29
+ cjsws=cjswnm              cjswd=cjswnm              mjsws=0.146
+ mjswd=0.146               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgnm            cjswgd=cjswgnm            mjswgs=0.713
+ mjswgd=0.713              tpb=0.00149               tcj=0.000913
+ tpbsw=0.001               tcjsw=0.000765            tpbswg=0.00115
+ tcjswg=0.00083            xtis=3                    xtid=3
+ jtsswgs=3.9893e-010       jtsswgd=3.9893e-010       njtsswg=17.974
+ xtsswgs=0.30393           xtsswgd=0.30393           tnjtsswg=0
+ vtsswgs=11.126            vtsswgd=11.126            dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rshg=8.23                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-4e-008               lku0=2e-007               wku0=2e-006
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ wvth0=0+dwvthnm           pvth0=0+dpvthnm           lcit=0+dlcitnm
+ pcit=0+dpcitnm            pvoff=0+dpvoffnm          pu0=0+dpu0nm
+ pvsat=0+dpvsatnm          pa0=0+dpa0nm              ppclm=0+dppclmnm
+ ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     5: type=n 
+ lmin=1e-005-(dxlnm+dlmisnm)                         lmax=2.001e-05
+ wmin=1.23e-006-(dxwnm+dwmisnm)                      wmax=1.003e-005-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.27338102+(dvthnm+vthmisnm)                   wvth0=2.6223819e-008+dwvthnm
+ k1=0.4215                 k2=0.021428693+dk2m       wk2=-1.5389241e-009
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.002494967       lkvth0we=0
+ wkvth0we=3.5118525e-011   pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00037243182+dcitnm
+ wcit=-2.760402e-010       voff=-0.087208068+dvoffnm wvoff=-1.7942613e-008
+ nfactor=1.0137841         wnfactor=-1.380201e-007   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.03968+du0nm          ua=-9.409475e-010         wua=6.0325826e-016
+ ub=3.3301408e-018         wub=-1.2229961e-024       uc=1.9549414e-010
+ wuc=-3.6989387e-017       vsat=88624.785+dvsatnm    wvsat=-0.00064869448
+ a0=1.8479036+da0nm        wa0=-4.1958111e-007       ags=0.66676281
+ wags=-6.2509304e-008      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.068282182
+ wketa=8.8332865e-009      dwg=0                     dwb=0
+ pclm=0.8839453+dpclmnm    wpclm=-4.8908803e-007     pdiblc1=0
+ pdiblc2=0.00075165316+dpdiblc2nm                    wpdiblc2=2.4378491e-010
+ pdiblcb=0.55              drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.2001967
+ wkt1=-6.0411399e-008      kt1l=0                    kt2=-0.039981652
+ wkt2=1.1179628e-009       ute=-1.7858003            wute=2.5933977e-007
+ ua1=3.6890328e-010        wua1=1.7083852e-015       ub1=-2.0437884e-019
+ wub1=-3.1135541e-024      uc1=-3.0500012e-010       wuc1=2.3580734e-016
+ prt=0                     at=9241.5505              wat=0.2117394
+ jss=2.34e-07              jsd=2.34e-07              jsws=7.68e-13
+ jswd=7.68e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.3                  bvd=11.3                  xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjnm                  cjd=cjnm                  mjs=0.333
+ mjd=0.333                 pbsws=0.29                pbswd=0.29
+ cjsws=cjswnm              cjswd=cjswnm              mjsws=0.146
+ mjswd=0.146               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgnm            cjswgd=cjswgnm            mjswgs=0.713
+ mjswgd=0.713              tpb=0.00149               tcj=0.000913
+ tpbsw=0.001               tcjsw=0.000765            tpbswg=0.00115
+ tcjswg=0.00083            xtis=3                    xtid=3
+ jtsswgs=3.9893e-010       jtsswgd=3.9893e-010       njtsswg=17.974
+ xtsswgs=0.30393           xtsswgd=0.30393           tnjtsswg=0
+ vtsswgs=11.126            vtsswgd=11.126            dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rshg=8.23                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-4e-008               lku0=2e-007               wku0=2e-006
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ lvth0=0+dlvthnm           pvth0=0+dpvthnm           lk2=0+dlk2m
+ lcit=0+dlcitnm            pcit=0+dpcitnm            lvoff=0+dlvoffnm
+ pvoff=0+dpvoffnm          lu0=0+dlu0nm              pu0=0+dpu0nm
+ lvsat=0+dlvsatnm          pvsat=0+dpvsatnm          la0=0+dla0nm
+ pa0=0+dpa0nm              lpclm=0+dlpclmnm          ppclm=0+dppclmnm
+ lpdiblc2=0+dlpdiblc2nm    ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     6: type=n 
+ lmin=1.2e-006-(dxlnm+dlmisnm)                       lmax=1e-005-(dxlnm+dlmisnm)
+ wmin=1.23e-006-(dxwnm+dwmisnm)                      wmax=1.003e-005-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.27145188+(dvthnm+vthmisnm)                   lvth0=1.9164926e-008+dlvthnm
+ wvth0=2.7469285e-008+dwvthnm                        pvth0=-1.2372974e-014+dpvthnm
+ k1=0.4215                 k2=0.022010666+dk2m       lk2=-5.7815634e-009+dlk2m
+ wk2=-1.1252518e-009       pk2=-4.109595e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025            lkvth0we=-5.0000074e-011  wkvth0we=3.2300037e-011
+ pkvth0we=2.800004e-017    k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00033954184+dcitnm lcit=-3.2674284e-010+dlcitnm
+ wcit=-3.4720964e-010      pcit=7.0702709e-016+dpcitnm
+ voff=-0.085913801+dvoffnm lvoff=-1.2857789e-008+dlvoffnm
+ wvoff=-1.7994211e-008     pvoff=5.1259464e-016+dpvoffnm
+ nfactor=1.0137841         wnfactor=-1.380201e-007   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.039665891+du0nm      lu0=1.4016267e-010+dlu0nm wu0=1.4127134e-010
+ pu0=-1.4034488e-015+dpu0nm                          ua=-9.2452375e-010
+ lua=-1.631605e-016        wua=5.7201666e-016        pua=3.1036722e-022
+ ub=3.3054279e-018         lub=2.4550888e-025        wub=-1.1512217e-024
+ pub=-7.1303682e-031       uc=1.9491912e-010         luc=5.712423e-018
+ wuc=-3.123178e-017        puc=-5.7198492e-023       vsat=86337.115+dvsatnm
+ lvsat=0.022726677+dlvsatnm                          wvsat=0.0020698001
+ pvsat=-2.7006667e-008+dpvsatnm                      a0=1.9060204+da0nm
+ la0=-5.77356e-007+dla0nm  wa0=-4.2064865e-007       pa0=1.0605406e-014+dpa0nm
+ ags=0.65550169            lags=1.1187273e-007       wags=-8.3683991e-008
+ pags=2.1035824e-013       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.067310401
+ lketa=-9.654078e-009      wketa=9.6873198e-009      pketa=-8.4843251e-015
+ dwg=0                     dwb=0                     pclm=0.89796275+dpclmnm
+ lpclm=-1.3925521e-007+dlpclmnm                      wpclm=-6.0917934e-007
+ ppclm=1.1930375e-012+dppclmnm                       pdiblc1=0
+ pdiblc2=0.00047559834+dpdiblc2nm                    lpdiblc2=2.7424445e-009+dlpdiblc2nm
+ wpdiblc2=3.4011808e-010   ppdiblc2=-9.570142e-016+dppdiblc2nm
+ pdiblcb=0.56200267        lpdiblcb=-1.1923958e-007  wpdiblcb=8.8961816e-009
+ ppdiblcb=-8.8378404e-014  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.19449669
+ lkt1=-5.6626361e-008      wkt1=-6.9248864e-008      pkt1=8.7795089e-014
+ kt1l=0                    kt2=-0.039442825          lkt2=-5.352936e-009
+ wkt2=9.8460802e-011       pkt2=1.0128161e-014       ute=-1.7706328
+ lute=-1.5067992e-007      wute=2.3099654e-007       pute=2.8157354e-013
+ ua1=2.8813026e-010        lua1=8.0243305e-016       wua1=1.9044535e-015
+ pua1=-1.9478243e-021      ub1=1.9010069e-020        lub1=-2.2192392e-024
+ wub1=-3.782593e-024       pub1=6.6465141e-030       uc1=-3.4227393e-010
+ luc1=3.7029371e-016       wuc1=2.9736891e-016       puc1=-6.1157844e-022
+ prt=0                     at=8245.2281              lat=0.009897885
+ wat=0.22171558            pat=-9.9107523e-008       jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     7: type=n 
+ lmin=5e-007-(dxlnm+dlmisnm)                         lmax=1.2e-006-(dxlnm+dlmisnm)
+ wmin=1.23e-006-(dxwnm+dwmisnm)                      wmax=1.003e-005-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29048613+(dvthnm+vthmisnm)                   lvth0=-2.4279126e-009+dlvthnm
+ wvth0=1.9988623e-008+dwvthnm                        pvth0=-3.8867623e-015+dpvthnm
+ k1=0.4215                 k2=0.017481508+dk2m       lk2=-6.4359685e-010+dlk2m
+ wk2=-7.694433e-009        pk2=3.3426156e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0024999999      lkvth0we=-4.9999985e-011  wkvth0we=3.2300122e-011
+ pkvth0we=2.7999944e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00084796581+dcitnm lcit=2.5002348e-010+dlcitnm
+ wcit=6.1866131e-010       pcit=-3.8867623e-016+dpcitnm
+ voff=-0.10084207+dvoffnm  lvoff=4.0771419e-009+dlvoffnm
+ wvoff=-1.6043388e-008     pvoff=-1.7004585e-015+dpvoffnm
+ nfactor=1.0137841         wnfactor=-1.380201e-007   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.039280972+du0nm      lu0=5.7682301e-010+dlu0nm wu0=3.99547e-009
+ pu0=-5.7757288e-015+dpu0nm                          ua=-1.1448555e-009
+ lua=8.6788284e-017        wua=1.4687242e-015        pua=-7.0687574e-022
+ ub=3.4685471e-018         lub=6.0463136e-026        wub=-2.2695461e-024
+ pub=5.5561267e-031        uc=1.9072028e-010         luc=1.0475675e-017
+ wuc=-9.9177762e-017       puc=1.9880789e-023        vsat=111054.63+dvsatnm
+ lvsat=-0.0053133667+dlvsatnm                        wvsat=-0.027001159
+ pvsat=5.9720103e-009+dpvsatnm                       a0=1.2635259+da0nm
+ la0=1.5150261e-007+dla0nm wa0=1.8689578e-008        pa0=-4.8778867e-013+dpa0nm
+ ags=0.90734442            lags=-1.738227e-007       wags=-5.6833758e-008
+ pags=1.7989879e-013       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.084881305
+ lketa=1.0278707e-008      wketa=2.2083216e-009      pketa=4.0947392e-030
+ dwg=0                     dwb=0                     pclm=0.66527774+dpclmnm
+ lpclm=1.2470731e-007+dlpclmnm                       wpclm=6.6617263e-007
+ ppclm=-2.5374728e-013+dppclmnm                      pdiblc1=0
+ pdiblc2=0.0022723574+dpdiblc2nm                     lpdiblc2=7.0416503e-010+dlpdiblc2nm
+ wpdiblc2=-1.4312296e-009  ppdiblc2=1.0524381e-015+dppdiblc2nm
+ pdiblcb=0.80249927        lpdiblcb=-3.9206373e-007  wpdiblcb=-1.118377e-007
+ ppdiblcb=4.8584529e-014   drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.23605962
+ lkt1=-9.4765394e-009      wkt1=-5.9042791e-009      pkt1=1.5935725e-014
+ kt1l=0                    kt2=-0.049574625          lkt2=6.1407811e-009
+ wkt2=1.8611338e-008       pkt2=-1.0873217e-014      ute=-1.8771105
+ lute=-2.9889518e-008      wute=5.4721608e-007       pute=-7.7152232e-014
+ ua1=1.0314157e-009        lua1=-4.0764803e-017      wua1=-1.4628165e-016
+ pua1=3.7857065e-022       ub1=-2.12351e-018         lub1=2.1127835e-025
+ wub1=3.9418381e-024       pub1=-2.116235e-030       uc1=-8.052542e-013
+ luc1=-1.7075187e-017      wuc1=-3.596467e-016       puc1=1.3375321e-022
+ prt=0                     at=8509.7956              lat=0.0095977544
+ wat=0.21818406            pat=-9.5101305e-008       jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     8: type=n 
+ lmin=2.85e-07             lmax=5e-007-(dxlnm+dlmisnm)
+ wmin=1.23e-006-(dxwnm+dwmisnm)                      wmax=1.003e-005-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29124246+(dvthnm+vthmisnm)                   lvth0=-2.7564774e-009+dlvthnm
+ wvth0=6.1884073e-009+dwvthnm                        pvth0=2.1083275e-015+dpvthnm
+ k1=0.4215                 k2=0.0037721656+dk2m      lk2=5.3120158e-009+dlk2m
+ wk2=-3.1286968e-009       pk2=1.3591685e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025170904      lkvth0we=-5.7424431e-011  wkvth0we=2.2729331e-011
+ pkvth0we=3.2157687e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00027627864+dcitnm lcit=1.6711368e-012+dlcitnm
+ wcit=-2.3752197e-010      pcit=-1.6733093e-017+dpcitnm
+ voff=-0.10021197+dvoffnm  lvoff=3.8034113e-009+dlvoffnm
+ wvoff=-5.1861811e-009     pvoff=-6.4170462e-015+dpvoffnm
+ nfactor=1.0323316         lnfactor=-8.057392e-009   wnfactor=-3.2373592e-007
+ pnfactor=8.0678666e-014   eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.043125481+du0nm
+ lu0=-1.0933088e-009+dlu0nm                          wu0=-1.8456167e-008
+ pu0=3.9777112e-015+dpu0nm ua=-1.1040138e-009        lua=6.9045835e-017
+ wua=-8.0838774e-016       pua=2.8234722e-022        ub=4.462348e-018
+ lub=-3.7126385e-025       wub=-8.50151e-025         pub=-6.1000943e-032
+ uc=2.2949156e-010         luc=-6.367346e-018        wuc=-6.5948627e-019
+ puc=-2.291752e-023        vsat=117299.26+dvsatnm    lvsat=-0.0080261568+dlvsatnm
+ wvsat=-0.029353755        pvsat=6.9940251e-009+dpvsatnm
+ a0=2.0720855+da0nm        la0=-1.9975186e-007+dla0nm
+ wa0=-2.311799e-006        pa0=5.2462216e-013+dpa0nm ags=0.80332371
+ lags=-1.2863402e-007      wags=1.9029637e-007       pags=7.2540522e-014
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.087519129         lketa=1.1424631e-008
+ wketa=4.717161e-008       pketa=-1.9532952e-014     dwg=0
+ dwb=0                     pclm=0.75849158+dpclmnm   lpclm=8.4213361e-008+dlpclmnm
+ wpclm=2.0204619e-008      ppclm=2.6874148e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=7.7815891e-005+dpdiblc2nm
+ lpdiblc2=1.6575178e-009+dlpdiblc2nm                 wpdiblc2=5.1923291e-009
+ ppdiblc2=-1.8249683e-015+dppdiblc2nm                pdiblcb=0.053169796
+ lpdiblcb=-6.6540022e-008  wpdiblcb=-1.8579499e-007  ppdiblcb=8.0713053e-014
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.28789127           lkt1=1.3040165e-008
+ wkt1=1.264629e-007        pkt1=-4.1567223e-014      kt1l=0
+ kt2=-0.041254031          lkt2=2.5261486e-009       wkt2=-1.0298804e-009
+ pkt2=-2.3406786e-015      ute=-2.3312013            lute=1.673766e-007
+ wute=3.3208722e-007       pute=1.6304048e-014       ua1=8.3610142e-011
+ lua1=3.7098088e-016       wua1=-2.0086289e-015      pua1=1.1876115e-021
+ ub1=-6.9645147e-019       lub1=-4.0866441e-025      wub1=3.0410597e-024
+ pub1=-1.7249189e-030      uc1=-3.8037319e-011       luc1=-9.0083335e-019
+ wuc1=-8.546075e-017       puc1=1.4641347e-023       prt=0
+ at=30583.576              lat=8.4627059e-006        wat=0.0066073804
+ pat=-3.1881623e-009       jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     9: type=n 
+ lmin=1e-005-(dxlnm+dlmisnm)                         lmax=2.001e-05
+ wmin=5.3e-007-(dxwnm+dwmisnm)                       wmax=1.23e-006-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29426714+(dvthnm+vthmisnm)                   wvth0=8.8895571e-010+dwvthnm
+ k1=0.4215                 k2=0.021742971+dk2m       wk2=-1.9201443e-009
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0024949671      lkvth0we=0
+ wkvth0we=3.5118462e-011   pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00052671429+dcitnm
+ wcit=-8.8895571e-011      voff=-0.094671429+dvoffnm wvoff=-8.8895571e-009
+ nfactor=0.82671429        wnfactor=8.8895571e-008   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.041631599+du0nm      wu0=-2.3672891e-009       ua=-4.5759559e-010
+ wua=1.6952385e-017        ub=2.6922127e-018         wub=-4.4918932e-025
+ uc=1.8713229e-010         wuc=-2.6846463e-017       vsat=87745.557+dvsatnm
+ wvsat=0.00041780919       a0=1.7233229+da0nm        wa0=-2.6846463e-007
+ ags=0.65677567            wags=-5.0394899e-008      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.063345143         wketa=2.8446583e-009      dwg=0
+ dwb=0                     pclm=0.17038966+dpclmnm   wpclm=3.7645497e-007
+ pdiblc1=0                 pdiblc2=0.0010820746+dpdiblc2nm
+ wpdiblc2=-1.5701625e-010  pdiblcb=0.58664286        wpdiblcb=-4.4447786e-008
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.26890771           wkt1=2.2935057e-008
+ kt1l=0                    kt2=-0.039060001          ute=-1.5148371
+ wute=-6.9338546e-008      ua1=1.9415333e-009        wua1=-1.9921498e-016
+ ub1=-2.527525e-018        wub1=-2.9557778e-025      uc1=-9.9020857e-011
+ wuc1=-1.40455e-017        prt=0                     at=181235
+ wat=0.003111345           jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 lvth0=0+dlvthnm           pvth0=0+dpvthnm
+ lk2=0+dlk2m               lcit=0+dlcitnm            pcit=0+dpcitnm
+ lvoff=0+dlvoffnm          pvoff=0+dpvoffnm          lu0=0+dlu0nm
+ pu0=0+dpu0nm              lvsat=0+dlvsatnm          pvsat=0+dpvsatnm
+ la0=0+dla0nm              pa0=0+dpa0nm              lpclm=0+dlpclmnm
+ ppclm=0+dppclmnm          lpdiblc2=0+dlpdiblc2nm    ppdiblc2=0+dppdiblc2nm
+ leta0=0+dleta0nm          peta0=0+dpeta0nm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noian_m
+ noib=noibn_m              noic=noicn_m              em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     10: type=n 
+ lmin=1.2e-006-(dxlnm+dlmisnm)                       lmax=1e-005-(dxlnm+dlmisnm)
+ wmin=5.3e-007-(dxwnm+dwmisnm)                       wmax=1.23e-006-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29345924+(dvthnm+vthmisnm)                   lvth0=8.0260768e-009+dlvthnm
+ wvth0=7.7435922e-010+dwvthnm                        pvth0=1.1384497e-015+dpvthnm
+ k1=0.4215                 k2=0.022862482+dk2m       lk2=-1.1121687e-008+dlk2m
+ wk2=-2.158505e-009        pk2=2.3679754e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025000001      lkvth0we=-5.0000087e-011  wkvth0we=3.2299973e-011
+ pkvth0we=2.8000056e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00057139128+dcitnm lcit=4.4384004e-010+dlcitnm
+ wcit=-6.5976273e-011      pcit=-2.2768994e-016+dpcitnm
+ voff=-0.092826405+dvoffnm lvoff=-1.832924e-008+dlvoffnm
+ wvoff=-9.6092231e-009     pvoff=7.1494641e-015+dpvoffnm
+ nfactor=0.81726692        lnfactor=9.3854056e-008   wnfactor=1.0035522e-007
+ pnfactor=-1.1384497e-013  eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.041985537+du0nm
+ lu0=-3.5161772e-009+dlu0nm                          wu0=-2.6724595e-009
+ pu0=3.0316915e-015+dpu0nm ua=-4.6166058e-010        lua=4.0383315e-017
+ wua=1.0563631e-017        pua=6.3468571e-023        ub=2.7443089e-018
+ lub=-5.1754584e-025       wub=-4.7058449e-025       pub=2.1254856e-031
+ uc=1.9464444e-010         luc=-7.462894e-017        wuc=-3.0898595e-017
+ puc=4.0255581e-023        vsat=89157.598+dvsatnm    lvsat=-0.01402781+dlvsatnm
+ wvsat=-0.0013514461       pvsat=1.7576525e-008+dpvsatnm
+ a0=1.8036111+da0nm        la0=-7.9761677e-007+dla0nm
+ wa0=-2.9642617e-007       pa0=2.7778173e-013+dpa0nm ags=0.61714733
+ lags=3.9368459e-007       wags=-3.716015e-008       pags=-1.3147956e-013
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.061971611         lketa=-1.3645245e-008
+ wketa=3.2113671e-009      pketa=-3.643039e-015      dwg=0
+ dwb=0                     pclm=0.026945169+dpclmnm  lpclm=1.4250378e-006+dlpclmnm
+ wpclm=4.4736498e-007      ppclm=-7.044499e-013+dppclmnm
+ pdiblc1=0                 pdiblc2=0.00091815608+dpdiblc2nm
+ lpdiblc2=1.628435e-009+dlpdiblc2nm                  wpdiblc2=-1.9670445e-010
+ ppdiblc2=3.9427928e-016+dppdiblc2nm                 pdiblcb=0.61070324
+ lpdiblcb=-2.3902597e-007  wpdiblcb=-5.017761e-008   ppdiblcb=5.6922485e-014
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.27448956           lkt1=5.5452379e-008
+ wkt1=2.7782489e-008       pkt1=-4.8156422e-014      kt1l=0
+ kt2=-0.039437232          lkt2=3.747576e-009        wkt2=9.1677195e-011
+ pkt2=-9.1075976e-016      ute=-1.4868147            lute=-2.783865e-007
+ wute=-1.1327484e-007      pute=4.3648161e-013       ua1=2.3065855e-009
+ lua1=-3.6265816e-015      wua1=-5.4393269e-016      pua1=3.4245705e-021
+ ub1=-3.3272102e-018       lub1=7.9444089e-024       wub1=2.7637218e-025
+ pub1=-5.6819911e-030      uc1=-7.9407113e-011       luc1=-1.9485117e-016
+ wuc1=-2.1488543e-017      puc1=7.3942308e-023       prt=0
+ at=177694.01              lat=0.035177655           wat=0.0161742
+ pat=-1.2977188e-007       jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     11: type=n 
+ lmin=5e-007-(dxlnm+dlmisnm)                         lmax=1.2e-006-(dxlnm+dlmisnm)
+ wmin=5.3e-007-(dxwnm+dwmisnm)                       wmax=1.23e-006-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.3059539+(dvthnm+vthmisnm)                    lvth0=-6.1481153e-009+dlvthnm
+ wvth0=1.2262255e-009+dwvthnm                        pvth0=6.2584354e-016+dpvthnm
+ k1=0.4215                 k2=0.0098778763+dk2m      lk2=3.608309e-009+dlk2m
+ wk2=1.5287727e-009        pk2=-1.8149463e-015       k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025            lkvth0we=-5.0000022e-011  wkvth0we=3.2300032e-011
+ pkvth0we=2.799999e-017    k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-2.7120629e-005+dcitnm
+ lcit=-1.7359148e-010+dlcitnm                        wcit=-3.770239e-010
+ pcit=1.2516871e-016+dpcitnm                         voff=-0.11439383+dvoffnm
+ lvoff=6.1372834e-009+dlvoffnm                       wvoff=3.9489724e-010
+ pvoff=-4.1994101e-015+dpvoffnm                      nfactor=0.85451889
+ lnfactor=5.1594686e-008   wnfactor=5.5168592e-008   pnfactor=-6.2584354e-014
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.042439313+du0nm      lu0=-4.030949e-009+dlu0nm
+ wu0=1.644024e-010         pu0=-1.8650137e-016+dpu0nm
+ ua=2.1769743e-011         lua=-5.0802971e-016       wua=5.3607733e-017
+ pua=1.463848e-023         ub=1.6822931e-018         lub=6.8722613e-025
+ wub=-1.0282e-025          pub=-2.0465084e-031       uc=7.1647684e-011
+ luc=6.4901046e-017        wuc=4.5257297e-017        puc=-4.6137186e-023
+ vsat=70093.492+dvsatnm    lvsat=0.0075988935+dlvsatnm
+ wvsat=0.022684701         pvsat=-9.6905613e-009+dpvsatnm
+ a0=1.3469087+da0nm        la0=-2.7952452e-007+dla0nm
+ wa0=-8.2453843e-008       pa0=3.5047238e-014+dpa0nm ags=0.90295225
+ lags=6.9461774e-008       wags=-5.1506051e-008      pags=-1.1520528e-013
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.081514402         lketa=8.524488e-009
+ wketa=-1.8757321e-009     pketa=2.127868e-015       dwg=0
+ dwb=0                     pclm=1.4050176+dpclmnm    lpclm=-1.3827515e-007+dlpclmnm
+ wpclm=-2.3113182e-007     ppclm=6.5250447e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=0.0014254861+dpdiblc2nm
+ lpdiblc2=1.0529096e-009+dlpdiblc2nm                 wpdiblc2=-4.0397474e-010
+ ppdiblc2=6.2941085e-016+dppdiblc2nm                 pdiblcb=0.71030001
+ lpdiblcb=-3.5201053e-007  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.22260406
+ lkt1=-3.4075676e-009      wkt1=-2.2225872e-008      pkt1=8.5740627e-015
+ kt1l=0                    kt2=-0.029856533          lkt2=-7.120961e-009
+ wkt2=-5.3067083e-009      pkt2=5.2132767e-015       ute=-1.6312426
+ lute=-1.1454463e-007      wute=2.4897829e-007       pute=2.5534416e-014
+ ua1=-1.578534e-009        lua1=7.8077564e-016       wua1=3.0195874e-015
+ pua1=-6.1795791e-022      ub1=6.4433307e-018        lub1=-3.1394881e-024
+ wub1=-6.4497397e-024      pub1=1.9482447e-030       uc1=-3.6118503e-010
+ luc1=1.2480333e-016       wuc1=7.7493971e-017       puc1=-3.8345435e-023
+ prt=0                     at=319606.71              lat=-0.12581095
+ wat=-0.1591765            pat=6.9149456e-008        jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     12: type=n 
+ lmin=2.85e-07             lmax=5e-007-(dxlnm+dlmisnm)
+ wmin=5.3e-007-(dxwnm+dwmisnm)                       wmax=1.23e-006-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.28895738+(dvthnm+vthmisnm)                   lvth0=1.2355124e-009+dlvthnm
+ wvth0=8.9602149e-009+dwvthnm                        pvth0=-2.7339561e-015+dpvthnm
+ k1=0.4215                 k2=0.0053696129+dk2m      lk2=5.5667888e-009+dlk2m
+ wk2=-5.0664004e-009       pk2=1.0501288e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025170904      lkvth0we=-5.7424447e-011  wkvth0we=2.2729301e-011
+ pkvth0we=3.2157706e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00018104609+dcitnm lcit=-1.0672318e-010+dlcitnm
+ wcit=-3.5303905e-010      pcit=1.1474921e-016+dpcitnm
+ voff=-0.083666986+dvoffnm lvoff=-7.2110739e-009+dlvoffnm
+ wvoff=-2.5255244e-008     pvoff=6.9435243e-015+dpvoffnm
+ nfactor=0.93742565        lnfactor=1.5578329e-008   wnfactor=-2.0861505e-007
+ pnfactor=5.2008536e-014   eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.030598998+du0nm
+ lu0=1.1127206e-009+dlu0nm wu0=-3.2615426e-009       pu0=1.3017977e-015+dpu0nm
+ ua=-1.9857284e-009        lua=3.6406763e-016        wua=2.6113202e-016
+ pua=-7.5514222e-023       ub=5.1749416e-018         lub=-8.3005022e-025
+ wub=-1.714527e-024        pub=4.9550692e-031        uc=3.6586384e-010
+ luc=-6.2912335e-017       wuc=-1.6607905e-016       puc=4.5671552e-023
+ vsat=100651.61+dvsatnm    lvsat=-0.0056761629+dlvsatnm
+ wvsat=-0.0091601583       pvsat=4.1434825e-009+dpvsatnm
+ a0=0.44652432+da0nm       la0=1.1162048e-007+dla0nm wa0=-3.3999326e-007
+ pa0=1.4692751e-013+dpa0nm ags=1.480447              lags=-1.8141349e-007
+ wags=-6.3105417e-007      pags=1.3656201e-013       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.049741217         lketa=-5.2784192e-009     wketa=1.3470019e-009
+ pketa=7.2784792e-016      dwg=0                     dwb=0
+ pclm=0.93364125+dpclmnm   lpclm=6.6500174e-008+dlpclmnm
+ wpclm=-1.9225193e-007     ppclm=4.8360244e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=0.0033513003+dpdiblc2nm
+ lpdiblc2=2.1629745e-010+dlpdiblc2nm                 wpdiblc2=1.2215924e-009
+ ppdiblc2=-7.676804e-017+dppdiblc2nm                 pdiblcb=-0.19865316
+ lpdiblcb=4.2856902e-008   wpdiblcb=1.1966626e-007   ppdiblcb=-5.1985415e-014
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.13995135           lkt1=-3.9313558e-008
+ wkt1=-5.2988223e-008      pkt1=2.1937843e-014       kt1l=0
+ kt2=-0.043566837          lkt2=-1.1649308e-009      wkt2=1.775553e-009
+ pkt2=2.1366007e-015       ute=-2.8618248            lute=4.200449e-007
+ wute=9.7573355e-007       pute=-2.901826e-013       ua1=-6.540704e-009
+ lua1=2.9364415e-015       wua1=6.0266642e-015       pua1=-1.9242922e-021
+ ub1=8.3094766e-018        lub1=-3.9501792e-024      wub1=-7.8831311e-024
+ pub1=2.5709386e-030       uc1=-6.4291305e-011       luc1=-4.1732417e-018
+ wuc1=-5.3614665e-017      puc1=1.8610779e-023       prt=0
+ at=30585.058              lat=-0.00025416397        wat=0.0066055828
+ pat=-2.8695961e-009       jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     13: type=n 
+ lmin=1e-005-(dxlnm+dlmisnm)                         lmax=2.001e-05
+ wmin=2.2e-07              wmax=5.3e-007-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.30909677+(dvthnm+vthmisnm)                   wvth0=-6.7186452e-009+dwvthnm
+ k1=0.4215                 k2=0.024548387+dk2m       wk2=-3.3593226e-009
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0024949671      lkvth0we=0
+ wkvth0we=3.5118459e-011   pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
