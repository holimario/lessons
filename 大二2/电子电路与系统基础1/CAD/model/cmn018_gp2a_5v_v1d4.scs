+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00037258065+dcitnm
+ wcit=-1.6796613e-010      voff=-0.11069032+dvoffnm  wvoff=-6.7186452e-010
+ nfactor=1.0654839         wnfactor=-3.3593226e-008  eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.035273165+du0nm      wu0=8.945876e-010         ua=-3.1090929e-010
+ wua=-5.8297684e-017       ub=1.2657497e-018         wub=2.8258622e-025
+ uc=1.6994519e-010         wuc=-1.8029484e-017       vsat=88867.774+dvsatnm
+ wvsat=-0.00015788816      a0=0.90008387+da0nm       wa0=1.5385697e-007
+ ags=0.48979503            wags=3.5266168e-008       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.062121935         wketa=2.2171529e-009      dwg=0
+ dwb=0                     pclm=1.2119745+dpclmnm    wpclm=-1.5787808e-007
+ pdiblc1=0                 pdiblc2=0.00025114677+dpdiblc2nm
+ wpdiblc2=2.692497e-010    pdiblcb=0.5982258         wpdiblcb=-5.0389835e-008
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.21758613           wkt1=-3.3929158e-009
+ kt1l=0                    kt2=-0.038654002          wkt2=-2.0827766e-010
+ ute=-1.7122097            wute=3.1913565e-008       ua1=1.4649277e-009
+ wua1=4.5283668e-017       ub1=-2.8605583e-018       wub1=-1.2473168e-025
+ uc1=-1.5172261e-010       wuc1=1.2990501e-017       prt=0
+ at=189591.94              wat=-0.0011757629         jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 lvth0=0+dlvthnm
+ pvth0=0+dpvthnm           lk2=0+dlk2m               lcit=0+dlcitnm
+ pcit=0+dpcitnm            lvoff=0+dlvoffnm          pvoff=0+dpvoffnm
+ lu0=0+dlu0nm              pu0=0+dpu0nm              lvsat=0+dlvsatnm
+ pvsat=0+dpvsatnm          la0=0+dla0nm              pa0=0+dpa0nm
+ lpclm=0+dlpclmnm          ppclm=0+dppclmnm          lpdiblc2=0+dlpdiblc2nm
+ ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     14: type=n 
+ lmin=1.2e-006-(dxlnm+dlmisnm)                       lmax=1e-005-(dxlnm+dlmisnm)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.30781223+(dvthnm+vthmisnm)                   lvth0=1.2761154e-008+dlvthnm
+ wvth0=-6.5887287e-009+dwvthnm                       pvth0=-1.2906446e-015+dpvthnm
+ k1=0.4215                 k2=0.025331569+dk2m       lk2=-7.7804617e-009+dlk2m
+ wk2=-3.4251469e-009       pk2=6.5392662e-016        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025000001      lkvth0we=-5.0000015e-011  wkvth0we=3.2299973e-011
+ pkvth0we=2.8000019e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00038102226+dcitnm lcit=8.386255e-011+dlcitnm
+ wcit=-1.6363558e-010      pcit=-4.3021488e-017+dpcitnm
+ voff=-0.11029627+dvoffnm  lvoff=-3.914646e-009+dlvoffnm
+ wvoff=-6.4718039e-010     pvoff=-2.4522248e-016+dpvoffnm
+ nfactor=1.0952582         lnfactor=-2.9579106e-007  wnfactor=-4.2254323e-008
+ pnfactor=8.6042976e-014   eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.034874455+du0nm
+ lu0=3.9609439e-009+dlu0nm wu0=9.7552556e-010        pu0=-8.0407161e-016+dpu0nm
+ ua=-3.5309472e-010        lua=4.1908781e-016        wua=-4.5130651e-017
+ pua=-1.3080683e-022       ub=1.2851134e-018         lub=-1.9236706e-025
+ wub=2.7798284e-025        pub=4.5731842e-032        uc=1.6905703e-010
+ luc=8.8234144e-018        wuc=-1.777225e-017        puc=-2.5554764e-024
+ vsat=86755.844+dvsatnm    lvsat=0.020980799+dlvsatnm
+ wvsat=-0.00011934628      pvsat=-3.8289124e-010+dpvsatnm
+ a0=0.90037247+da0nm       la0=-2.8670251e-009+dla0nm
+ wa0=1.6693523e-007        pa0=-1.2992489e-013+dpa0nm
+ ags=0.48704082            lags=2.73615e-008         wags=2.9584489e-008
+ pags=5.6444192e-014       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.06128293
+ lketa=-8.3350286e-009     wketa=2.8580741e-009      pketa=-6.3671802e-015
+ dwg=0                     dwb=0                     pclm=1.2546345+dpclmnm
+ lpclm=-4.2380212e-007+dlpclmnm                      wpclm=-1.8243966e-007
+ ppclm=2.4400497e-013+dppclmnm                       pdiblc1=0
+ pdiblc2=6.2952692e-005+dpdiblc2nm                   lpdiblc2=1.8695991e-009+dlpdiblc2nm
+ wpdiblc2=2.4201489e-010   ppdiblc2=2.7056214e-016+dppdiblc2nm
+ pdiblcb=0.62462352        lpdiblcb=-2.6224604e-007  wpdiblcb=-5.7318713e-008
+ ppdiblcb=6.8834381e-014   drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.21106812
+ lkt1=-6.475263e-008       wkt1=-4.7527081e-009      pkt1=1.3508747e-014
+ kt1l=0                    kt2=-0.038275963          lkt2=-3.7555963e-009
+ wkt2=-5.0405413e-010      pkt2=2.9383676e-015       ute=-1.7778526
+ lute=6.5212428e-007       wute=3.6027586e-008       pute=-4.0870414e-014
+ ua1=9.8540142e-010        lua1=4.7638159e-015       wua1=1.3383473e-016
+ pua1=-8.7970339e-022      ub1=-2.246456e-018        lub1=-6.1007509e-024
+ wub1=-2.7805476e-025      pub1=1.5231759e-030       uc1=-1.4699507e-010
+ luc1=-4.6965463e-017      wuc1=1.3184077e-017       puc1=-1.9230618e-024
+ prt=0                     at=211971.29              lat=-0.22232594
+ wat=-0.0014100455         pat=2.3274621e-009        jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     15: type=n 
+ lmin=5e-007-(dxlnm+dlmisnm)                         lmax=1.2e-006-(dxlnm+dlmisnm)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.3286886+(dvthnm+vthmisnm)                    lvth0=-1.092141e-008+dlvthnm
+ wvth0=-1.0436676e-008+dwvthnm                       pvth0=3.074544e-015+dpvthnm
+ k1=0.4215                 k2=0.017106451+dk2m       lk2=1.5502771e-009+dlk2m
+ wk2=-2.1794862e-009       pk2=-7.5917586e-016       k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025000001      lkvth0we=-5.000007e-011   wkvth0we=3.2299978e-011
+ pkvth0we=2.8000014e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-3.4031613e-006+dcitnm
+ lcit=-3.4451611e-010+dlcitnm                        wcit=-3.8919096e-010
+ pcit=2.1285304e-016+dpcitnm                         voff=-0.10975879+dvoffnm
+ lvoff=-4.5243799e-009+dlvoffnm                      wvoff=-1.9828811e-009
+ pvoff=1.2700232e-015+dpvoffnm                       nfactor=0.89657613
+ lnfactor=-7.0402105e-008  wnfactor=3.3593226e-008   pnfactor=4.9679238e-029
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.044453872+du0nm      lu0=-6.9061377e-009+dlu0nm
+ wu0=-8.6906643e-010       pu0=1.2884704e-015+dpu0nm ua=6.0180554e-010
+ lua=-6.6417014e-016       wua=-2.4395063e-016       pua=9.4738525e-023
+ ub=6.5727347e-019         lub=5.1986709e-025        wub=4.230151e-025
+ pub=-1.1879565e-031       uc=2.133548e-010          luc=-4.1428868e-017
+ wuc=-2.7438455e-017       puc=8.4100603e-024        vsat=122993.5+dvsatnm
+ lvsat=-0.020127926+dlvsatnm                         wvsat=-0.0044530041
+ pvsat=4.5332968e-009+dpvsatnm                       a0=0.98080136+da0nm
+ la0=-9.4107175e-008+dla0nm                          wa0=1.0535924e-007
+ pa0=-6.0071859e-014+dpa0nm                          ags=0.6041304
+ lags=-1.0546726e-007      wags=1.0178956e-007       pags=-2.5466684e-014
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.073867786         lketa=5.9414835e-009
+ wketa=-5.7984461e-009     pketa=3.4529494e-015      dwg=0
+ dwb=0                     pclm=1.029089+dpclmnm     lpclm=-1.6793882e-007+dlpclmnm
+ wpclm=-3.828047e-008      ppclm=8.0467911e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=-0.0013310708+dpdiblc2nm
+ lpdiblc2=3.4510072e-009+dlpdiblc2nm                 wpdiblc2=1.010139e-009
+ ppdiblc2=-6.0081319e-016+dppdiblc2nm                pdiblcb=0.69968769
+ lpdiblcb=-3.4740033e-007  wpdiblcb=5.4441205e-009   ppdiblcb=-2.3650326e-015
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.28837103           lkt1=2.2941332e-008
+ wkt1=1.1512582e-008       pkt1=-4.942923e-015       kt1l=0
+ kt2=-0.044255352          lkt2=3.027542e-009        wkt2=2.0798857e-009
+ pkt2=7.0946284e-018       ute=-1.1398089            lute=-7.168524e-008
+ wute=-3.1271934e-009      pute=3.5475507e-015       ua1=5.7428456e-009
+ lua1=-6.3312391e-016      wua1=-7.3628035e-016      pua1=1.0737256e-022
+ ub1=-8.4882791e-018       lub1=9.800981e-025        wub1=1.2101761e-024
+ pub1=-1.6510303e-031      uc1=-2.4885713e-010       luc1=6.8588905e-017
+ wuc1=1.986976e-017        puc1=-9.5074348e-024      prt=0
+ at=7294.1915              lat=0.0098638559          wat=0.0010398256
+ pat=-4.5172075e-010       jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     16: type=n 
+ lmin=2.85e-07             lmax=5e-007-(dxlnm+dlmisnm)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwnm+dwmisnm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxnm+toxmisnm)     toxm=(toxnm+toxmisnm)     dtox=4.295e-010
+ epsrox=3.9                wint=8.5e-009             lint=2.529e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlnm+dlmisnm)
+ xw=0+(dxwnm+dwmisnm)      dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.33044+(dvthnm+vthmisnm)                      lvth0=-1.1682253e-008+dlvthnm
+ wvth0=-1.2320368e-008+dwvthnm                       pvth0=3.8928574e-015+dpvthnm
+ k1=0.4215                 k2=0.0074423781+dk2m      lk2=5.7485436e-009+dlk2m
+ wk2=-6.129729e-009        pk2=9.5688862e-016        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0026160151      lkvth0we=-1.003993e-010   wkvth0we=-2.8019053e-011
+ pkvth0we=5.4203808e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.0029051815+dcitnm  lcit=9.1607446e-010+dlcitnm
+ wcit=1.0444424e-009       pcit=-4.0994598e-016+dpcitnm
+ voff=-0.16858891+dvoffnm  lvoff=2.1032602e-008+dlvoffnm
+ wvoff=1.8309704e-008      pvoff=-7.5454815e-015+dpvoffnm
+ nfactor=0.37399833        lnfactor=1.5661614e-007   wnfactor=8.0423164e-008
+ pnfactor=-2.0343862e-014  eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.012314766+du0nm
+ lu0=7.0557326e-009+dlu0nm wu0=6.1182683e-009        pu0=-1.7469675e-015+dpu0nm
+ ua=-1.9311316e-009        lua=4.3618839e-016        wua=2.3312385e-016
+ pua=-1.1251217e-022       ub=1.5570098e-018         lub=1.2900364e-025
+ wub=1.4147203e-025        pub=3.5122889e-033        uc=-9.607384e-012
+ luc=5.5430365e-017        wuc=2.6537682e-017        puc=-1.5038253e-023
+ vsat=58952.332+dvsatnm    lvsat=0.0076928398+dlvsatnm
+ wvsat=0.01223157          pvsat=-2.7148158e-009+dpvsatnm
+ a0=-0.88631388+da0nm      la0=7.1700503e-007+dla0nm wa0=3.4375274e-007
+ pa0=-1.6363476e-013+dpa0nm                          ags=0.16371667
+ lags=8.5857274e-008       wags=4.4428488e-008       pags=-5.4788754e-016
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.026967797         lketa=-1.443281e-008
+ wketa=-1.0335762e-008     pketa=5.4240503e-015      dwg=0
+ dwb=0                     pclm=0.048062856+dpclmnm  lpclm=2.5823858e-007+dlpclmnm
+ wpclm=2.6204978e-007      ppclm=-5.0001558e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=0.0050956954+dpdiblc2nm
+ lpdiblc2=6.5909141e-010+dlpdiblc2nm                 wpdiblc2=3.2671775e-010
+ ppdiblc2=-3.0392134e-016+dppdiblc2nm                pdiblcb=0.17696291
+ lpdiblcb=-1.2031824e-007  wpdiblcb=-7.3024789e-008  ppdiblcb=3.1723431e-014
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.25070184           lkt1=6.5770824e-009
+ wkt1=3.8267757e-009       pkt1=-1.6040551e-015      kt1l=0
+ kt2=-0.056119943          lkt2=8.1817576e-009       wkt2=8.2152962e-009
+ pkt2=-2.6582504e-015      ute=-0.5847423            lute=-3.1281728e-007
+ wute=-1.9240979e-007      pute=8.5775695e-014       ua1=7.6256844e-009
+ lua1=-1.4510668e-015      wua1=-1.2406931e-015      pua1=3.2649954e-022
+ ub1=-1.0148334e-017       lub1=1.7012591e-024       wub1=1.5857256e-024
+ pub1=-3.2824923e-031      uc1=-1.9000503e-010       luc1=4.3022373e-017
+ wuc1=1.0876475e-017       puc1=-5.6005716e-024      prt=0
+ at=57696.289              lat=-0.012031823          wat=-0.0073024788
+ pat=3.1723431e-009        jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
     } 
ends mench_mac
// 
 
// *********************************************************************************************
//                                                                            
//                   *
//                                1.8V MED-VT PMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
// *********************************
//        Mismatch   model         * 
// *********************************
 
inline subckt mepch_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2.05e-007 dmci=3.15e-007 
+ xw= + 0 + dxwpm ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf 
+ * dmcg + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor 
+ + (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 
+ 1) * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.00e-05 / factor sb=1.00e-05 / factor 
+ sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_m 
+ temp1=par1p_m temp2=par2p_m fac1=0.909065 * temp1 * sigma + 0.416655 * temp2 * 
+ sigma fac2=0.909065 * temp1 * sigma - 0.416655 * temp2 * sigma lef=l * factor 
+ - 1.5e-08 wef=w / nf * factor + 0 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) 
+ vthmispm=0.00309015 * geo_fac * fac1 * mismatchflag dlmispm=0.00258677 * geo_fac 
+ * lef * fac2 * mismatchflag dwmispm= - 0.00258677 * geo_fac * wef * fac2 * mismatchflag 
+ toxmispm=0.00258677 * geo_fac * toxpm * fac2 * mismatchflag 
mepch_mac ( n1 n2 n3 n4 ) mepch w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model mepch bsim4  { 
     1: type=p 
+ lmin=1e-005-(dxlpm+dlmispm)                         lmax=2.001e-05
+ wmin=1.003e-005-(dxwpm+dwmispm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.152+(dvthpm+vthmispm)                       k1=0.1926
+ k2=0.046064+dk2pm         k3=0.1                    k3b=0.1
+ w0=0                      dvt0=9.8                  dvt1=1.38
+ dvt2=0.05                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.7                  minv=-0.3
+ voffl=0                   dvtp0=4.617e-006          dvtp1=1.1
+ lpe0=6.841e-008           lpeb=1.217e-007           web=0
+ wec=0                     scref=1e-006              kvth0we=-0.0022480615
+ lkvth0we=0                wkvth0we=0                pkvth0we=0
+ k2we=0.0023               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.6e-007               ngate=7.65e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00080985+dcitpm    voff=-0.096782+dvoffpm    nfactor=0.7107
+ eta0=0.21+deta0pm         etab=-0.05096             ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.016493               ua=2.751e-009+duapm
+ ub=2.014e-019             uc=4.958e-011             vsat=152900
+ a0=1.656                  ags=0.74044+dagspm        a1=0
+ a2=0.5705                 b0=0                      b1=0
+ keta=-0.043               dwg=0                     dwb=0
+ pclm=0.83966              pdiblc1=0                 pdiblc2=0.0029299+dpdiblc2pm
+ pdiblcb=2.5737481e-010    drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.3138
+ kt1l=0                    kt2=-0.018                ute=-1.552
+ ua1=1.804e-009            ub1=-8.267e-018           uc1=-2.971e-010
+ prt=0                     at=283100                 jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  lvth0=0+dlvthpm
+ wvth0=0+dwvthpm           pvth0=0+dpvthpm           lk2=0+dlk2pm
+ wk2=0+dwk2pm              pk2=0+dpk2pm              lcit=0+dlcitpm
+ wcit=0+dwcitpm            pcit=0+dpcitpm            lvoff=0+dlvoffpm
+ wvoff=0+dwvoffpm          pvoff=0+dpvoffpm          lnfactor=0+dlnfactorpm
+ lua=0+dluapm              wua=0+dwuapm              pua=0+dpuapm
+ lpclm=0+dlpclmpm          wpclm=0+dwpclmpm          ppclm=0+dppclmpm
+ lpdiblc2=0+dlpdiblc2pm    wpdiblc2=0+dwpdiblc2pm    ppdiblc2=0+dppdiblc2pm
+ leta0=0+dleta0pm          weta0=0+dweta0pm          peta0=0+dpeta0pm
+ lvsat=0+dlvsatpm          wvsat=0+dwvsatpm          pvsat=0+dpvsatpm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noiap_m              noib=noibp_m              noic=noicp_m
+ em=2.10e7                 ef=1.12                   minr=1e-3
 
 
 
     2: type=p 
+ lmin=1.2e-006-(dxlpm+dlmispm)                       lmax=1e-005-(dxlpm+dlmispm)
+ wmin=1.003e-005-(dxwpm+dwmispm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15091651+(dvthpm+vthmispm)                  lvth0=-1.0800782e-008+dlvthpm
+ k1=0.1926                 k2=0.045203313+dk2pm      lk2=8.5797392e-009+dlk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022538798     lkvth0we=5.800007e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.000901866+dcitpm
+ lcit=9.172591e-010+dlcitpm                          voff=-0.094412122+dvoffpm
+ lvoff=-2.3624064e-008+dlvoffpm                      nfactor=0.70096714
+ lnfactor=9.7021735e-008+dlnfactorpm                 eta0=0.21+deta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.016470826            lu0=2.2104543e-010        ua=2.8349841e-009+duapm
+ lua=-8.3719301e-016+dluapm                          ub=3.8743108e-020
+ lub=1.621441e-024         uc=4.8950617e-011         luc=6.2739839e-018
+ vsat=152900               a0=1.7077846              la0=-5.1621387e-007
+ ags=0.72307754+dagspm     lags=1.7307724e-007       a1=0
+ a2=0.5705                 b0=0                      b1=0
+ keta=-0.041034839         lketa=-1.9589655e-008     dwg=0
+ dwb=0                     pclm=0.7829837            lpclm=5.6497623e-007+dlpclmpm
+ pdiblc1=0                 pdiblc2=0.0029537475+dpdiblc2pm
+ lpdiblc2=-2.377231e-010+dlpdiblc2pm                 pdiblcb=0.039834341
+ lpdiblcb=-3.9708759e-007  drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.30755929
+ lkt1=-6.2210389e-008      kt1l=0                    kt2=-0.016164965
+ lkt2=-1.8292503e-008      ute=-1.6069714            lute=5.4798088e-007
+ ua1=1.2800456e-009        lua1=5.2230255e-015       ub1=-7.6836925e-018
+ lub1=-5.814686e-024       uc1=-3.0506687e-010       luc1=7.9417518e-017
+ prt=0                     at=290097.57              lat=-0.069755054
+ jss=1.48e-07              jsd=1.48e-07              jsws=4.06e-13
+ jswd=4.06e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.1                  bvd=11.1                  xjbvs=1
+ xjbvd=1                   pbs=0.886                 pbd=0.886
+ cjs=cjpm                  cjd=cjpm                  mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswpm              cjswd=cjswpm              mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgpm            cjswgd=cjswgpm            mjswgs=0.70189
+ mjswgd=0.70189            tpb=0.00161               tcj=9.18e-04
+ tpbsw=0.00125             tcjsw=8.86e-04            tpbswg=0.00115
+ tcjswg=0.00158            xtis=3                    xtid=3
+ jtsswgs=5.4876e-010       jtsswgd=5.4876e-010       dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ rshg=8.41                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wlod=5e-006
+ kvth0=-2.3e-009           lkvth0=5e-008             wkvth0=2.5e-007
+ pkvth0=4e-014             llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=4.8e-008              lku0=2.5e-007             wku0=1e-008
+ pku0=-1e-012              llodku0=1                 wlodku0=1
+ kvsat=-0.6                steta0=0                  tku0=0.5
+ wvth0=0+dwvthpm           pvth0=0+dpvthpm           wk2=0+dwk2pm
+ pk2=0+dpk2pm              wcit=0+dwcitpm            pcit=0+dpcitpm
+ wvoff=0+dwvoffpm          pvoff=0+dpvoffpm          wua=0+dwuapm
+ pua=0+dpuapm              wpclm=0+dwpclmpm          ppclm=0+dppclmpm
+ wpdiblc2=0+dwpdiblc2pm    ppdiblc2=0+dppdiblc2pm    leta0=0+dleta0pm
+ weta0=0+dweta0pm          peta0=0+dpeta0pm          lvsat=0+dlvsatpm
+ wvsat=0+dwvsatpm          pvsat=0+dpvsatpm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     3: type=p 
+ lmin=5e-007-(dxlpm+dlmispm)                         lmax=1.2e-006-(dxlpm+dlmispm)
+ wmin=1.003e-005-(dxwpm+dwmispm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.16430934+(dvthpm+vthmispm)                  lvth0=4.8483972e-009+dlvthpm
+ k1=0.1926                 k2=0.053645575+dk2pm      lk2=-1.2848253e-009+dlk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022538798     lkvth0we=5.7999969e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-5.5864685e-005+dcitpm
+ lcit=-7.1271439e-011+dlcitpm                        voff=-0.11210024+dvoffpm
+ lvoff=-2.9559583e-009+dlvoffpm                      nfactor=0.78667699
+ lnfactor=-3.1279982e-009+dlnfactorpm                eta0=0.21+deta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.01666                ua=2.097084e-009+duapm    lua=2.5023986e-017+dluapm
+ ub=1.3802888e-018         lub=5.3879769e-026        uc=4.7694439e-011
+ luc=7.7417956e-018        vsat=162108.86            lvsat=-0.010760314+dlvsatpm
+ a0=1.266                  ags=0.72677616+dagspm     lags=1.687555e-007
+ a1=0                      a2=0.5705                 b0=0
+ b1=0                      keta=-0.055658405         lketa=-2.5023986e-009
+ dwg=0                     dwb=0                     pclm=1.0110478
+ lpclm=2.9848923e-007+dlpclmpm                       pdiblc1=0
+ pdiblc2=0.0031907325+dpdiblc2pm                     lpdiblc2=-5.1463391e-010+dlpdiblc2pm
+ pdiblcb=-0.26653757       lpdiblcb=-3.9099978e-008  drout=0.5
+ pvag=0.895                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0.017
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=200                  rsw=140                   rdw=140
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=2.593e-009          bgidl=2.5204e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgopm                cgdo=cgopm
+ cgbo=0                    cgdl=cglpm                cgsl=cglpm
+ clc=1e-007                cle=0.6                   cf=cfpm
+ ckappas=0.6               ckappad=0.6               acde=0.3322
+ moin=9.77                 noff=1.919                voffcv=-0.0543
+ kt1=-0.34025407           lkt1=-2.4007386e-008      kt1l=0
+ kt2=-0.053115491          lkt2=2.4883227e-008       ute=-1.0770984
+ lute=-7.116196e-008       ua1=6.4573957e-009        lua1=-8.2657353e-016
+ ub1=-1.3677258e-017       lub1=1.1886393e-024       uc1=-7.1862528e-011
+ luc1=-1.9307569e-016      prt=0                     at=219758.95
+ lat=0.012433793           jss=1.48e-07              jsd=1.48e-07
+ jsws=4.06e-13             jswd=4.06e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.1                  bvd=11.1
+ xjbvs=1                   xjbvd=1                   pbs=0.886
+ pbd=0.886                 cjs=cjpm                  cjd=cjpm
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswpm              cjswd=cjswpm
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgpm            cjswgd=cjswgpm
+ mjswgs=0.70189            mjswgd=0.70189            tpb=0.00161
+ tcj=9.18e-04              tpbsw=0.00125             tcjsw=8.86e-04
+ tpbswg=0.00115            tcjswg=0.00158            xtis=3
+ xtid=3                    jtsswgs=5.4876e-010       jtsswgd=5.4876e-010
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             rshg=8.41                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=5e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=4.8e-008              lku0=2.5e-007
+ wku0=1e-008               pku0=-1e-012              llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  wvth0=0+dwvthpm           pvth0=0+dpvthpm
+ wk2=0+dwk2pm              pk2=0+dpk2pm              wcit=0+dwcitpm
+ pcit=0+dpcitpm            wvoff=0+dwvoffpm          pvoff=0+dpvoffpm
+ wua=0+dwuapm              pua=0+dpuapm              wpclm=0+dwpclmpm
+ ppclm=0+dppclmpm          wpdiblc2=0+dwpdiblc2pm    ppdiblc2=0+dppdiblc2pm
+ leta0=0+dleta0pm          weta0=0+dweta0pm          peta0=0+dpeta0pm
+ wvsat=0+dwvsatpm          pvsat=0+dpvsatpm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     4: type=p 
+ lmin=2.5e-07              lmax=5e-007-(dxlpm+dlmispm)
+ wmin=1.003e-005-(dxwpm+dwmispm)                     wmax=90.003e-05
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15226464+(dvthpm+vthmispm)                  lvth0=-7.9423126e-010+dlvthpm
+ k1=0.1926                 k2=0.048013026+dk2pm      lk2=1.3538777e-009+dlk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022538798     lkvth0we=5.8000007e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5.230624e-006+dcitpm
+ lcit=-9.9893003e-011+dlcitpm                        voff=-0.1115237+dvoffpm
+ lvoff=-3.2260527e-009+dlvoffpm                      nfactor=0.58774288
+ lnfactor=9.0067462e-008+dlnfactorpm                 eta0=0.31967307+deta0pm
+ leta0=-5.1378984e-008+dleta0pm                      etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.017242015
+ lu0=-2.7265877e-010       ua=2.8309154e-009+duapm   lua=-3.1875694e-016+dluapm
+ ub=1.127652e-018          lub=1.7223355e-025        uc=8.3052459e-011
+ luc=-8.8225173e-018       vsat=166781.33            lvsat=-0.012949245+dlvsatpm
+ a0=1.6068194              la0=-1.5966505e-007       ags=1.3622772+dagspm
+ lags=-1.2896023e-007      a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.062398234
+ lketa=6.5503609e-010      dwg=0                     dwb=0
+ pclm=2.1834613            lpclm=-2.50756e-007+dlpclmpm
+ pdiblc1=0                 pdiblc2=0.002594865+dpdiblc2pm
+ lpdiblc2=-2.3548547e-010+dlpdiblc2pm                pdiblcb=-0.5247792
+ lpdiblcb=8.1879511e-008   drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.384771
+ lkt1=-3.1523612e-009      kt1l=0                    kt2=0.035654956
+ lkt2=-1.670342e-008       ute=-1.3705712            lute=6.6322404e-008
+ ua1=4.9857552e-009        lua1=-1.3714818e-016      ub1=-1.2959452e-017
+ lub1=8.5236591e-025       uc1=-7.9501959e-010       luc1=1.4570459e-016
+ prt=0                     at=439203.8               lat=-0.090370417
+ jss=1.48e-07              jsd=1.48e-07              jsws=4.06e-13
+ jswd=4.06e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.1                  bvd=11.1                  xjbvs=1
+ xjbvd=1                   pbs=0.886                 pbd=0.886
+ cjs=cjpm                  cjd=cjpm                  mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswpm              cjswd=cjswpm              mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgpm            cjswgd=cjswgpm            mjswgs=0.70189
+ mjswgd=0.70189            tpb=0.00161               tcj=9.18e-04
+ tpbsw=0.00125             tcjsw=8.86e-04            tpbswg=0.00115
+ tcjswg=0.00158            xtis=3                    xtid=3
+ jtsswgs=5.4876e-010       jtsswgd=5.4876e-010       dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ rshg=8.41                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wlod=5e-006
+ kvth0=-2.3e-009           lkvth0=5e-008             wkvth0=2.5e-007
+ pkvth0=4e-014             llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=4.8e-008              lku0=2.5e-007             wku0=1e-008
+ pku0=-1e-012              llodku0=1                 wlodku0=1
+ kvsat=-0.6                steta0=0                  tku0=0.5
+ wvth0=0+dwvthpm           pvth0=0+dpvthpm           wk2=0+dwk2pm
+ pk2=0+dpk2pm              wcit=0+dwcitpm            pcit=0+dpcitpm
+ wvoff=0+dwvoffpm          pvoff=0+dpvoffpm          wua=0+dwuapm
+ pua=0+dpuapm              wpclm=0+dwpclmpm          ppclm=0+dppclmpm
+ wpdiblc2=0+dwpdiblc2pm    ppdiblc2=0+dppdiblc2pm    weta0=0+dweta0pm
+ peta0=0+dpeta0pm          wvsat=0+dwvsatpm          pvsat=0+dpvsatpm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noiap_m              noib=noibp_m              noic=noicp_m
+ em=2.10e7                 ef=1.12                   minr=1e-3
 
 
 
     5: type=p 
+ lmin=1e-005-(dxlpm+dlmispm)                         lmax=2.001e-05
+ wmin=1.23e-006-(dxwpm+dwmispm)                      wmax=1.003e-005-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15120896+(dvthpm+vthmispm)                  wvth0=-7.9514975e-009+dwvthpm
+ k1=0.1926                 k2=0.045888151+dk2pm      wk2=1.7676351e-009+dwk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022441817     lkvth0we=0
+ wkvth0we=-3.899995e-011   pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00092506957+dcitpm
+ wcit=1.1581871e-009+dwcitpm                         voff=-0.094680916+dvoffpm
+ wvoff=-2.1120093e-008+dwvoffpm                      nfactor=0.73498595
+ wnfactor=-2.4412242e-007  eta0=0.21+deta0pm         etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.01646924
+ wu0=2.3883095e-010        ua=2.744114e-009+duapm    wua=6.9218072e-017+dwuapm
+ ub=2.5870745e-019         wub=-5.7605453e-025       uc=5.4432923e-011
+ wuc=-4.8781579e-017       vsat=152900               a0=1.6483173
+ wa0=7.7226775e-008        ags=0.75216896+dagspm     wags=-1.1789954e-007
+ a1=0                      a2=0.5705                 b0=0
+ b1=0                      keta=-0.042743909         wketa=-2.5742258e-009
+ dwg=0                     dwb=0                     pclm=0.74135808
+ wpclm=9.8813088e-007+dwpclmpm                       pdiblc1=0
+ pdiblc2=0.0029927703+dpdiblc2pm                     wpdiblc2=-6.3197244e-010+dwpdiblc2pm
+ pdiblcb=-5.2018262e-011   wpdiblcb=3.1100192e-015   drout=0.5
+ pvag=0.895                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0.017
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=200                  rsw=140                   rdw=140
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=2.593e-009          bgidl=2.5204e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgopm                cgdo=cgopm
+ cgbo=0                    cgdl=cglpm                cgsl=cglpm
+ clc=1e-007                cle=0.6                   cf=cfpm
+ ckappas=0.6               ckappad=0.6               acde=0.3322
+ moin=9.77                 noff=1.919                voffcv=-0.0543
+ kt1=-0.31324514           wkt1=-5.5774893e-009      kt1l=0
+ kt2=-0.018967455          wkt2=9.7248531e-009       ute=-1.5713491
+ wute=1.9449706e-007       ua1=1.586465e-009         wua1=2.1866618e-015
+ ub1=-7.9934095e-018       wub1=-2.7501312e-024      uc1=-2.9002905e-010
+ wuc1=-7.1077235e-017      prt=0                     at=285262.55
+ wat=-0.021737907          jss=1.48e-07              jsd=1.48e-07
+ jsws=4.06e-13             jswd=4.06e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.1                  bvd=11.1
+ xjbvs=1                   xjbvd=1                   pbs=0.886
+ pbd=0.886                 cjs=cjpm                  cjd=cjpm
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswpm              cjswd=cjswpm
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgpm            cjswgd=cjswgpm
+ mjswgs=0.70189            mjswgd=0.70189            tpb=0.00161
+ tcj=9.18e-04              tpbsw=0.00125             tcjsw=8.86e-04
+ tpbswg=0.00115            tcjswg=0.00158            xtis=3
+ xtid=3                    jtsswgs=5.4876e-010       jtsswgd=5.4876e-010
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             rshg=8.41                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=5e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=4.8e-008              lku0=2.5e-007
+ wku0=1e-008               pku0=-1e-012              llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lvth0=0+dlvthpm           pvth0=0+dpvthpm
+ lk2=0+dlk2pm              pk2=0+dpk2pm              lcit=0+dlcitpm
+ pcit=0+dpcitpm            lvoff=0+dlvoffpm          pvoff=0+dpvoffpm
+ lnfactor=0+dlnfactorpm    lua=0+dluapm              pua=0+dpuapm
+ lpclm=0+dlpclmpm          ppclm=0+dppclmpm          lpdiblc2=0+dlpdiblc2pm
+ ppdiblc2=0+dppdiblc2pm    leta0=0+dleta0pm          weta0=0+dweta0pm
+ peta0=0+dpeta0pm          lvsat=0+dlvsatpm          wvsat=0+dwvsatpm
+ pvsat=0+dpvsatpm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noiap_m              noib=noibp_m
+ noic=noicp_m              em=2.10e7                 ef=1.12
+ minr=1e-3
 
 
 
     6: type=p 
+ lmin=1.2e-006-(dxlpm+dlmispm)                       lmax=1e-005-(dxlpm+dlmispm)
+ wmin=1.23e-006-(dxwpm+dwmispm)                      wmax=1.003e-005-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15009298+(dvthpm+vthmispm)                  lvth0=-1.1124686e-008+dlvthpm
+ wvth0=-8.2781147e-009+dwvthpm                       pvth0=3.2558744e-015+dpvthpm
+ k1=0.1926                 k2=0.045040083+dk2pm      lk2=8.4539443e-009+dlk2pm
+ wk2=1.6407861e-009+dwk2pm pk2=1.2644908e-015+dpk2pm k3=0.1
+ k3b=0.1                   w0=0                      dvt0=9.8
+ dvt1=1.38                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.3                 voffl=0                   dvtp0=4.617e-006
+ dvtp1=1.1                 lpe0=6.841e-008           lpeb=1.217e-007
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=-0.00225          lkvth0we=5.8000088e-011   wkvth0we=-3.8999931e-011
+ pkvth0we=-1.8929502e-022  k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=7.65e+019           ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.0010415116+dcitpm  lcit=1.1607495e-009+dlcitpm
+ wcit=1.4037177e-009+dwcitpm                         pcit=-2.4475657e-015+dpcitpm
+ voff=-0.09198426+dvoffpm  lvoff=-2.6881551e-008+dlvoffpm
+ wvoff=-2.4404874e-008+dwvoffpm                      pvoff=3.2744253e-014+dpvoffpm
+ nfactor=0.72859116        lnfactor=6.3746336e-008+dlnfactorpm
+ wnfactor=-2.7767663e-007  pnfactor=3.3448431e-013   eta0=0.21+deta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.016443911            lu0=2.5249416e-010        wu0=2.705432e-010
+ pu0=-3.1612269e-016       ua=2.8345475e-009+duapm   lua=-9.0148401e-016+dluapm
+ wua=4.3883686e-018+dwuapm pua=6.4625321e-022+dpuapm ub=8.6453488e-020
+ lub=1.7171092e-024        wub=-4.7958474e-025       pub=-9.6165658e-031
+ uc=5.4358373e-011         luc=7.4314943e-019        wuc=-5.4358757e-017
+ puc=5.5595949e-023        vsat=152900               a0=1.6990818
+ la0=-5.0604482e-007       wa0=8.7481033e-008        pa0=-1.0221931e-013
+ ags=0.73465311+dagspm     lags=1.7460637e-007       wags=-1.1635761e-007
+ pags=-1.5370756e-014      a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.040650289
+ lketa=-2.0870202e-008     wketa=-3.8655029e-009     pketa=1.2872062e-014
+ dwg=0                     dwb=0                     pclm=0.6781787
+ lpclm=6.2980205e-007+dlpclmpm                       wpclm=1.0534999e-006+dwpclmpm
+ ppclm=-6.5162919e-013+dppclmpm                      pdiblc1=0
+ pdiblc2=0.0030641233+dpdiblc2pm                     lpdiblc2=-7.112808e-010+dlpdiblc2pm
+ wpdiblc2=-1.1094981e-009+dwpdiblc2pm                ppdiblc2=4.760202e-015+dppdiblc2pm
+ pdiblcb=0.039834341       lpdiblcb=-3.9708759e-007  wpdiblcb=3.522971e-015
+ ppdiblcb=-4.1164997e-021  drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.30674939
+ lkt1=-6.4752652e-008      wkt1=-8.141054e-009       pkt1=2.5554828e-014
+ kt1l=0                    kt2=-0.01724161           lkt2=-1.7204038e-008
+ wkt2=1.0822438e-008       pkt2=-1.0941251e-014      ute=-1.6333102
+ lute=6.1765772e-007       wute=2.6475772e-007       pute=-7.0039159e-013
+ ua1=9.890808e-010         lua1=5.9550089e-015       wua1=2.9247786e-015
+ pua1=-7.3578976e-021      ub1=-7.3358032e-018       lub1=-6.5553319e-024
+ wub1=-3.4969831e-024      pub1=7.4449733e-030       uc1=-2.9802992e-010
+ luc1=7.9756487e-017       wuc1=-7.0735426e-017      puc1=-3.4073104e-024
+ prt=0                     at=292654.94              lat=-0.073690853
+ wat=-0.025706685          pat=3.956266e-008         jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  leta0=0+dleta0pm
+ weta0=0+dweta0pm          peta0=0+dpeta0pm          lvsat=0+dlvsatpm
+ wvsat=0+dwvsatpm          pvsat=0+dpvsatpm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     7: type=p 
+ lmin=5e-007-(dxlpm+dlmispm)                         lmax=1.2e-006-(dxlpm+dlmispm)
+ wmin=1.23e-006-(dxwpm+dwmispm)                      wmax=1.003e-005-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.16347737+(dvthpm+vthmispm)                  lvth0=4.5146256e-009+dlvthpm
+ wvth0=-8.36301e-009+dwvthpm                         pvth0=3.3550724e-015+dpvthpm
+ k1=0.1926                 k2=0.053396873+dk2pm      lk2=-1.3107482e-009+dlk2pm
+ wk2=2.4999524e-009+dwk2pm pk2=2.6057729e-016+dpk2pm k3=0.1
+ k3b=0.1                   w0=0                      dvt0=9.8
+ dvt1=1.38                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.3                 voffl=0                   dvtp0=4.617e-006
+ dvtp1=1.1                 lpe0=6.841e-008           lpeb=1.217e-007
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=-0.0022499999     lkvth0we=5.7999957e-011   wkvth0we=-3.9000189e-011
+ pkvth0we=1.1183575e-022   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=7.65e+019           ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=5.9637258e-005+dcitpm lcit=-1.2591431e-010+dlcitpm
+ wcit=-1.1610255e-009+dwcitpm                        pcit=5.4927009e-016+dpcitpm
+ voff=-0.11260873+dvoffpm  lvoff=-2.7823971e-009+dlvoffpm
+ wvoff=5.1113081e-009+dwvoffpm                       pvoff=-1.7446377e-015+dpvoffpm
+ nfactor=0.78620422        lnfactor=-3.5730271e-009+dlnfactorpm
+ wnfactor=4.7523151e-009   pnfactor=4.4734299e-015   eta0=0.21+deta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.01666                ua=2.0178984e-009+duapm   lua=5.2749282e-017+dluapm
+ wua=7.9597457e-016+dwuapm pua=-2.7869468e-022+dpuapm
+ ub=1.6100616e-018         lub=-6.3187292e-026       wub=-2.3096765e-024
+ pub=1.1767581e-030        uc=4.3699428e-011         luc=1.3197849e-017
+ wuc=4.0157851e-017        puc=-5.484425e-023        vsat=163220.98
+ lvsat=-0.012059798+dlvsatpm                         wvsat=-0.011179038+dwvsatpm
+ pvsat=1.3062415e-008+dpvsatpm                       a0=1.2876997
+ la0=-2.5355518e-008       wa0=-2.1812524e-007       pa0=2.5487367e-013
+ ags=0.74628359+dagspm     lags=1.6101645e-007       wags=-1.9608869e-007
+ pags=7.7792946e-014       a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.056845847
+ lketa=-1.9461125e-009     wketa=1.1936174e-008      pketa=-5.5917873e-015
+ dwg=0                     dwb=0                     pclm=0.90664904
+ lpclm=3.628404e-007+dlpclmpm                        wpclm=1.0494166e-006+dwpclmpm
+ ppclm=-6.4685796e-013+dppclmpm                      pdiblc1=0
+ pdiblc2=0.0027358956+dpdiblc2pm                     lpdiblc2=-3.2775517e-010+dlpdiblc2pm
+ wpdiblc2=4.5720207e-009+dwpdiblc2pm                 ppdiblc2=-1.878505e-015+dppdiblc2pm
+ pdiblcb=-0.26177678       lpdiblcb=-4.4662838e-008  wpdiblcb=-4.7855471e-008
+ ppdiblcb=5.5917873e-014   drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.34197219
+ lkt1=-2.3595735e-008      wkt1=1.7270509e-008       pkt1=-4.1379226e-015
+ kt1l=0                    kt2=-0.056290377          lkt2=2.8423431e-008
+ wkt2=3.1913952e-008       pkt2=-3.5586136e-014      ute=-1.0055298
+ lute=-1.1588736e-007      wute=-7.1940734e-007      pute=4.495797e-013
+ ua1=7.1229881e-009        lua1=-1.2123023e-015      wua1=-6.690534e-015
+ pua1=3.8773451e-021       ub1=-1.4281247e-017       lub1=1.5602384e-024
+ wub1=6.0712976e-024       pub1=-3.7353139e-030      uc1=-3.5266138e-011
+ luc1=-2.2727616e-016      wuc1=-3.6786691e-016      puc1=3.437831e-022
+ prt=0                     at=219062.25              lat=0.012300284
+ wat=0.0070031838          pat=1.342029e-009         jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  leta0=0+dleta0pm
+ weta0=0+dweta0pm          peta0=0+dpeta0pm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     8: type=p 
+ lmin=2.5e-07              lmax=5e-007-(dxlpm+dlmispm)
+ wmin=1.23e-006-(dxwpm+dwmispm)                      wmax=1.003e-005-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15411579+(dvthpm+vthmispm)                  lvth0=1.2896953e-010+dlvthpm
+ wvth0=1.8607722e-008+dwvthpm                        pvth0=-9.2800143e-015+dpvthpm
+ k1=0.1926                 k2=0.04630628+dk2pm       lk2=2.0110103e-009+dlk2pm
+ wk2=1.7156206e-008+dwk2pm pk2=-6.6054966e-015+dpk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.00225          lkvth0we=5.8000007e-011
+ wkvth0we=-3.899995e-011   pkvth0we=-5.3891099e-031  k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5.5769611e-006+dcitpm
+ lcit=-1.0058846e-010+dlcitpm                        wcit=-3.4813805e-012+dwcitpm
+ pcit=6.990749e-018+dpcitpm                          voff=-0.11409487+dvoffpm
+ lvoff=-2.0861764e-009+dlvoffpm                      wvoff=2.5845434e-008+dwvoffpm
+ pvoff=-1.1458037e-014+dpvoffpm                      nfactor=0.53385223
+ lnfactor=1.1464732e-007+dlnfactorpm                 wnfactor=5.417088e-007
+ pnfactor=-2.4707672e-013  eta0=0.33476556+deta0pm   leta0=-5.844942e-008+dleta0pm
+ weta0=-1.5170966e-007+dweta0pm                      peta0=7.1072029e-014+dpeta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.017345086            lu0=-3.2094479e-010       wu0=-1.0360684e-009
+ pu0=4.853711e-016         ua=2.859252e-009+duapm    lua=-3.4140302e-016+dluapm
+ wua=-2.8483918e-016+dwuapm                          pua=2.2763846e-022+dpuapm
+ ub=1.1770235e-018         lub=1.396798e-025         wub=-4.9628281e-025
+ pub=3.2723028e-031        uc=9.8249569e-011         luc=-1.2357474e-017
+ wuc=-1.5276135e-016       puc=3.553338e-023         vsat=173352.82
+ lvsat=-0.016806302+dlvsatpm                         wvsat=-0.066056627+dwvsatpm
+ pvsat=3.8771139e-008+dpvsatpm                       a0=1.5662145
+ la0=-1.5583245e-007       wa0=4.0816118e-007        pa0=-3.8525233e-014
+ ags=1.4275675+dagspm      lags=-1.5814735e-007      wags=-6.5629785e-007
+ pags=2.9338897e-013       a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.062597164
+ lketa=7.4822986e-010      wketa=1.9996495e-009      pketa=-9.3678378e-016
+ dwg=0                     dwb=0                     pclm=2.2340424
+ lpclm=-2.5900889e-007+dlpclmpm                      wpclm=-5.0844153e-007+dwpclmpm
+ ppclm=8.2958059e-014+dppclmpm                       pdiblc1=0
+ pdiblc2=0.0025143324+dpdiblc2pm                     lpdiblc2=-2.2395857e-010+dlpdiblc2pm
+ wpdiblc2=8.0951396e-010+dwpdiblc2pm                 ppdiblc2=-1.1586844e-016+dppdiblc2pm
+ pdiblcb=-0.56297573       lpdiblcb=9.6441038e-008   wpdiblcb=3.839515e-007
+ ppdiblcb=-1.4637247e-013  drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.39047177
+ lkt1=-8.749384e-010       wkt1=5.7304174e-008       pkt1=-2.2892654e-014
+ kt1l=0                    kt2=0.043540619           lkt2=-1.8344795e-008
+ wkt2=-7.9266689e-008      pkt2=1.6499104e-014       ute=-1.4478112
+ lute=9.1309984e-008       wute=7.7641709e-007       pute=-2.5117515e-013
+ ua1=4.690091e-009         lua1=-7.2553249e-017      wua1=2.9720159e-015
+ pua1=-6.4930826e-022      ub1=-1.2604868e-017       lub1=7.7489864e-025
+ wub1=-3.5642743e-024      pub1=7.7870099e-031       uc1=-8.8548655e-010
+ luc1=1.7103e-016          wuc1=9.0937388e-016       puc1=-2.54571e-022
+ prt=0                     at=438157.47              lat=-0.090340128
+ wat=0.010517773           pat=-3.0446468e-010       jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     9: type=p 
+ lmin=1e-005-(dxlpm+dlmispm)                         lmax=2.001e-05
+ wmin=5.3e-007-(dxwpm+dwmispm)                       wmax=1.23e-006-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15595131+(dvthpm+vthmispm)                  wvth0=-2.0140745e-009+dwvthpm
+ k1=0.1926                 k2=0.045959429+dk2pm      wk2=1.6783954e-009+dwk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022441817     lkvth0we=0
+ wkvth0we=-3.8999986e-011  pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00047314286+dcitpm
+ wcit=-5.9237486e-010+dwcitpm                        voff=-0.11737754+dvoffpm
+ wvoff=7.2960837e-009+dwvoffpm                       nfactor=0.17725714
+ wnfactor=4.5415406e-007   eta0=0.21+deta0pm         etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.01666
+ ua=2.8951326e-009+duapm   wua=-1.1985718e-016+dwuapm
+ ub=-1.2987657e-019        wub=-8.9547333e-026       uc=8.7040571e-012
+ wuc=8.4709605e-018        vsat=152900               a0=1.7525829
+ wa0=-5.3313737e-008       ags=0.65218034+dagspm     wags=7.2862107e-009
+ a1=0                      a2=0.5705                 b0=0
+ b1=0                      keta=-0.051266286         wketa=8.0957897e-009
+ dwg=0                     dwb=0                     pclm=2.2243063
+ wpclm=-8.6852027e-007+dwpclmpm                      pdiblc1=0
+ pdiblc2=0.0017530514+dpdiblc2pm                     wpdiblc2=9.2015561e-010+dwpdiblc2pm
+ pdiblcb=0.11828572        wpdiblcb=-1.4809372e-007  drout=0.5
+ pvag=0.895                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0.017
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=200                  rsw=140                   rdw=140
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=2.593e-009          bgidl=2.5204e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgopm                cgdo=cgopm
+ cgbo=0                    cgdl=cglpm                cgsl=cglpm
+ clc=1e-007                cle=0.6                   cf=cfpm
+ ckappas=0.6               ckappad=0.6               acde=0.3322
+ moin=9.77                 noff=1.919                voffcv=-0.0543
+ kt1=-0.30311143           wkt1=-1.8264891e-008      kt1l=0
+ kt2=-0.0086608            wkt2=-3.1790784e-009      ute=-1.3056
+ wute=-1.382208e-007       ua1=3.9528171e-009        wua1=-7.7601106e-016
+ ub1=-1.1152845e-017       wub1=1.2054825e-024       uc1=-3.8275886e-010
+ wuc1=4.5020489e-017       prt=0                     at=264509.14
+ wat=0.0042453531          jss=1.48e-07              jsd=1.48e-07
+ jsws=4.06e-13             jswd=4.06e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.1                  bvd=11.1
+ xjbvs=1                   xjbvd=1                   pbs=0.886
+ pbd=0.886                 cjs=cjpm                  cjd=cjpm
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswpm              cjswd=cjswpm
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgpm            cjswgd=cjswgpm
+ mjswgs=0.70189            mjswgd=0.70189            tpb=0.00161
+ tcj=9.18e-04              tpbsw=0.00125             tcjsw=8.86e-04
+ tpbswg=0.00115            tcjswg=0.00158            xtis=3
+ xtid=3                    jtsswgs=5.4876e-010       jtsswgd=5.4876e-010
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             rshg=8.41                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=5e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=4.8e-008              lku0=2.5e-007
+ wku0=1e-008               pku0=-1e-012              llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lvth0=0+dlvthpm           pvth0=0+dpvthpm
+ lk2=0+dlk2pm              pk2=0+dpk2pm              lcit=0+dlcitpm
+ pcit=0+dpcitpm            lvoff=0+dlvoffpm          pvoff=0+dpvoffpm
+ lnfactor=0+dlnfactorpm    lua=0+dluapm              pua=0+dpuapm
+ lpclm=0+dlpclmpm          ppclm=0+dppclmpm          lpdiblc2=0+dlpdiblc2pm
+ ppdiblc2=0+dppdiblc2pm    leta0=0+dleta0pm          weta0=0+dweta0pm
+ peta0=0+dpeta0pm          lvsat=0+dlvsatpm          wvsat=0+dwvsatpm
+ pvsat=0+dpvsatpm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noiap_m              noib=noibp_m
+ noic=noicp_m              em=2.10e7                 ef=1.12
+ minr=1e-3
 
 
 
     10: type=p 
+ lmin=1.2e-006-(dxlpm+dlmispm)                       lmax=1e-005-(dxlpm+dlmispm)
+ wmin=5.3e-007-(dxwpm+dwmispm)                       wmax=1.23e-006-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.1543622+(dvthpm+vthmispm)                   lvth0=-1.5840996e-008+dlvthpm
+ wvth0=-2.9330412e-009+dwvthpm                       pvth0=9.1606955e-015+dpvthpm
+ k1=0.1926                 k2=0.045681846+dk2pm      lk2=2.7670727e-009+dlk2pm
+ wk2=8.3729839e-010+dwk2pm pk2=8.3844539e-015+dpk2pm k3=0.1
+ k3b=0.1                   w0=0                      dvt0=9.8
+ dvt1=1.38                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.3                 voffl=0                   dvtp0=4.617e-006
+ dvtp1=1.1                 lpe0=6.841e-008           lpeb=1.217e-007
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=-0.00225          lkvth0we=5.7999937e-011   wkvth0we=-3.8999986e-011
+ pkvth0we=2.4069911e-030   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=7.65e+019           ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00065751895+dcitpm  lcit=-1.8379483e-009+dlcitpm
+ wcit=-7.2346853e-010+dwcitpm                        pcit=1.3068039e-015+dpcitpm
+ voff=-0.11751183+dvoffpm  lvoff=1.3386768e-009+dlvoffpm
+ wvoff=7.5556491e-009+dwvoffpm                       pvoff=-2.5874718e-015+dpvoffpm
+ nfactor=0.10217889        lnfactor=7.4841557e-007+dlnfactorpm
+ wnfactor=5.0659153e-007   pnfactor=-5.2272157e-013  eta0=0.20582217+deta0pm
+ leta0=4.1646547e-008+dleta0pm                       weta0=5.2306377e-009+dweta0pm
+ peta0=-5.2141476e-014+dpeta0pm                      etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.016625132
+ lu0=3.4757644e-010        wu0=4.3654195e-011        pu0=-4.351657e-016
+ ua=2.8990223e-009+duapm   lua=-3.8774658e-017+dluapm
+ wua=-7.6334078e-017+dwuapm                          pua=-4.338589e-022+dpuapm
+ ub=-1.9928541e-019        lub=6.9190024e-025        wub=-1.2183964e-025
+ pub=3.2190501e-031        uc=2.8744265e-012         luc=5.8112521e-017
+ wuc=1.0099144e-017        puc=-1.6230505e-023       vsat=152100.04
+ lvsat=0.0079744265+dlvsatpm                         wvsat=0.0010015557+dwvsatpm
+ pvsat=-9.9839819e-009+dpvsatpm                      a0=1.8587817
+ la0=-1.0586401e-006       wa0=-1.124632e-007        pa0=5.8962993e-013
+ ags=0.63064394+dagspm     lags=2.1468507e-007       wags=1.386187e-008
+ pags=-6.5549285e-014      a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.051230169
+ lketa=-3.6002608e-010     wketa=9.3805078e-009      pketa=-1.2806678e-014
+ dwg=0                     dwb=0                     pclm=2.5699406
+ lpclm=-3.4454466e-006+dlpclmpm                      wpclm=-1.314986e-006+dwpclmpm
+ ppclm=4.4505821e-012+dppclmpm                       pdiblc1=0
+ pdiblc2=0.0011608915+dpdiblc2pm                     lpdiblc2=5.9029309e-009+dlpdiblc2pm
+ wpdiblc2=1.2733482e-009+dwpdiblc2pm                 ppdiblc2=-3.5207911e-015+dppdiblc2pm
+ pdiblcb=0.17906154        lpdiblcb=-6.0584222e-007  wpdiblcb=-1.7431245e-007
+ ppdiblcb=2.6136079e-013   drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.30053752
+ lkt1=-2.5657909e-008      wkt1=-1.5918315e-008      pkt1=-2.339179e-014
+ kt1l=0                    kt2=-0.0060561956         lkt2=-2.5963931e-008
+ wkt2=-3.1817003e-009      pkt2=2.6136078e-017       ute=-1.306207
+ lute=6.0508585e-009       wute=-1.4477548e-007      pute=6.5340196e-014
+ ua1=4.0220477e-009        lua1=-6.9012311e-016      wua1=-8.7249601e-016
+ pua1=9.6180768e-022       ub1=-1.1156789e-017       lub1=3.931514e-026
+ wub1=1.2868917e-024       pub1=-8.1152484e-031      uc1=-3.9053907e-010
+ luc1=7.7556879e-017       wuc1=4.5086036e-017       puc1=-6.5340196e-025
+ prt=0                     at=266270.96              lat=-0.017562617
+ wat=0.0073260546          pat=-3.0709892e-008       jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     11: type=p 
+ lmin=5e-007-(dxlpm+dlmispm)                         lmax=1.2e-006-(dxlpm+dlmispm)
+ wmin=5.3e-007-(dxwpm+dwmispm)                       wmax=1.23e-006-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.18208226+(dvthpm+vthmispm)                  lvth0=1.6549166e-008+dlvthpm
+ wvth0=1.4930315e-008+dwvthpm                        pvth0=-1.1712172e-014+dpvthpm
+ k1=0.1926                 k2=0.046197574+dk2pm      lk2=2.1644586e-009+dlk2pm
+ wk2=1.1513476e-008+dwk2pm pk2=-4.0903816e-015+dpk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022500001     lkvth0we=5.8000047e-011
+ wkvth0we=-3.8999986e-011  pkvth0we=2.5850801e-031   k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0016053282+dcitpm
+ lcit=8.0612983e-010+dlcitpm                         wcit=9.2351127e-010+dwcitpm
+ pcit=-6.1764917e-016+dpcitpm                        voff=-0.11486117+dvoffpm
+ lvoff=-1.7585606e-009+dlvoffpm                      wvoff=7.9313607e-009+dwvoffpm
+ pvoff=-3.0264809e-015+dpvoffpm                      nfactor=0.82184826
+ lnfactor=-9.2499376e-008+dlnfactorpm                wnfactor=-3.9874021e-008
+ pnfactor=1.1580922e-013   eta0=0.26252124+deta0pm   leta0=-2.4604834e-008+dleta0pm
+ weta0=-6.5756589e-008+dweta0pm                      peta0=3.0805252e-014+dpeta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.017098335            lu0=-2.0534861e-010       wu0=-5.4879559e-010
+ pu0=2.5709647e-016        ua=3.3227829e-009+duapm   lua=-5.3392785e-016+dluapm
+ wua=-8.3774082e-016+dwuapm                          pua=4.5582508e-022+dpuapm
+ ub=-8.7253762e-019        lub=1.4785779e-024        wub=7.985377e-025
+ pub=-7.5353198e-031       uc=5.1232828e-011         luc=1.6069867e-018
+ wuc=3.0726035e-017        puc=-4.0332491e-023       vsat=165446.46
+ lvsat=-0.0076205186+dlvsatpm                        wvsat=-0.013965332+dwvsatpm
+ pvsat=7.5044374e-009+dpvsatpm                       a0=0.28987036
+ la0=7.7459201e-007        wa0=1.0311571e-006        pa0=-7.4666064e-013
+ ags=0.50889233+dagspm     lags=3.5694866e-007       wags=1.0112516e-007
+ pags=-1.6751417e-013      a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.042567295
+ lketa=-1.0482369e-008     wketa=-5.9405726e-009     pketa=5.0956056e-015
+ dwg=0                     dwb=0                     pclm=-1.884615
+ lpclm=1.7595858e-006+dlpclmpm                       wpclm=4.5440791e-006+dwpclmpm
+ ppclm=-2.3955832e-012+dppclmpm                      pdiblc1=0
+ pdiblc2=0.011944037+dpdiblc2pm                      lpdiblc2=-6.696894e-009+dlpdiblc2pm
+ wpdiblc2=-6.9565721e-009+dwpdiblc2pm                ppdiblc2=6.0956568e-015+dppdiblc2pm
+ pdiblcb=-0.28665354       lpdiblcb=-6.1666251e-008  wpdiblcb=-1.6709766e-008
+ ppdiblcb=7.7206146e-014   drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.27224193
+ lkt1=-5.872057e-008       wkt1=-7.0031766e-008      pkt1=3.9838371e-014
+ kt1l=0                    kt2=-0.028065471          lkt2=-2.46665e-010
+ wkt2=-3.4236299e-009      pkt2=3.0882458e-016       ute=-1.5445241
+ lute=2.8451825e-007       wute=-4.4586422e-008      pute=-5.1728118e-014
+ ua1=7.8837106e-010        lua1=3.088344e-015        wua1=1.2404065e-015
+ pua1=-1.507064e-021       ub1=-8.8068621e-018       lub1=-2.7065138e-024
+ wub1=-7.8263205e-025      pub1=1.6066598e-030       uc1=-3.4708003e-010
+ luc1=2.6776119e-017       wuc1=2.2524089e-017       puc1=2.5709647e-023
+ prt=0                     at=223752.81              lat=0.032118733
+ wat=0.0011306033          pat=-2.3470668e-008       jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     12: type=p 
+ lmin=2.5e-07              lmax=5e-007-(dxlpm+dlmispm)
+ wmin=5.3e-007-(dxwpm+dwmispm)                       wmax=1.23e-006-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.11660731+(dvthpm+vthmispm)                  lvth0=-1.4124145e-008+dlvthpm
+ wvth0=-2.8352893e-008+dwvthpm                       pvth0=8.5648856e-015+dpvthpm
+ k1=0.1926                 k2=0.063592353+dk2pm      lk2=-5.984543e-009+dlk2pm
+ wk2=-4.485956e-009+dwk2pm pk2=3.4049361e-015+dpk2pm k3=0.1
+ k3b=0.1                   w0=0                      dvt0=9.8
+ dvt1=1.38                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.3                 voffl=0                   dvtp0=4.617e-006
+ dvtp1=1.1                 lpe0=6.841e-008           lpeb=1.217e-007
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=-0.0022500001     lkvth0we=5.8000039e-011   wkvth0we=-3.89999e-011
+ pkvth0we=-4.0419469e-023  k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=7.65e+019           ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0010322043+dcitpm   lcit=-4.2948559e-010+dlcitpm
+ wcit=-1.2888188e-009+dwcitpm                        pcit=4.1876996e-016+dpcitpm
+ voff=-0.078686963+dvoffpm lvoff=-1.8705234e-008+dlvoffpm
+ wvoff=-1.8485269e-008+dwvoffpm                      pvoff=9.3490233e-015+dpvoffpm
+ nfactor=0.94013113        lnfactor=-1.4791183e-007+dlnfactorpm
+ wnfactor=3.3047614e-008   pnfactor=8.1647329e-014   eta0=0.21528697+deta0pm
+ leta0=-2.4768084e-009+dleta0pm                      weta0=-2.1224635e-009+dweta0pm
+ peta0=9.9431895e-016+dpeta0pm                       etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.016175747
+ lu0=2.2686005e-010        wu0=4.2794386e-010        pu0=-2.0048057e-016
+ ua=2.460655e-009+duapm    lua=-1.3004338e-016+dluapm
+ wua=2.1420421e-016+dwuapm pua=-3.6983815e-023+dpuapm
+ ub=1.452202e-018          lub=3.8949789e-025        wub=-8.4080627e-025
+ pub=1.4458044e-032        uc=3.4441232e-011         luc=9.4734126e-018
+ wuc=-7.2873313e-017       puc=8.2011104e-024        vsat=87093.256
+ lvsat=0.029085918+dlvsatpm                          wvsat=0.041940349+dwvsatpm
+ pvsat=-1.8685921e-008+dpvsatpm                      a0=2.7921815
+ la0=-3.9767568e-007       wa0=-1.1267495e-006       pa0=2.6426249e-013
+ ags=0.95400668+dagspm     lags=1.4842416e-007       wags=-6.3399679e-008
+ pags=-9.0438563e-014      a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.06618329
+ lketa=5.8111059e-010      wketa=6.4894792e-009      pketa=-7.2755045e-016
+ dwg=0                     dwb=0                     pclm=2.5668983
+ lpclm=-3.2583247e-007+dlpclmpm                      wpclm=-9.2517712e-007+dwpclmpm
+ ppclm=1.6662118e-013+dppclmpm                       pdiblc1=0
+ pdiblc2=-0.0054211036+dpdiblc2pm                    lpdiblc2=1.4382227e-009+dlpdiblc2pm
+ wpdiblc2=1.074468e-008+dwpdiblc2pm                  ppdiblc2=-2.1969194e-015+dppdiblc2pm
+ pdiblcb=-0.31946056       lpdiblcb=-4.6297015e-008  wpdiblcb=7.9070512e-008
+ ppdiblcb=3.2335576e-014   drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.32836473
+ lkt1=-3.2428497e-008      wkt1=-2.0453841e-008      pkt1=1.6612402e-014
+ kt1l=0                    kt2=-0.013669851          lkt2=-6.9906387e-009
+ wkt2=-7.6391797e-009      pkt2=2.2837e-015          ute=-0.20651937
+ lute=-3.423022e-007       wute=-7.7768029e-007      pute=2.917073e-013
+ ua1=1.1754734e-008        lua1=-2.049112e-015       wua1=-5.8729174e-015
+ pua1=1.8253433e-021       ub1=-2.1551128e-017       lub1=3.2638433e-024
+ wub1=7.6364425e-024       pub1=-2.3374577e-030      uc1=-1.6474062e-010
+ luc1=-5.8645155e-017      wuc1=6.9999815e-018       puc1=3.2982287e-023
+ prt=0                     at=516558.17              lat=-0.10505296
+ wat=-0.087639902          pat=1.8116005e-008        jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     13: type=p 
+ lmin=1e-005-(dxlpm+dlmispm)                         lmax=2.001e-05
+ wmin=2.2e-07              wmax=5.3e-007-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15913161+(dvthpm+vthmispm)                  wvth0=-2.5854968e-010+dwvthpm
+ k1=0.1926                 k2=0.055245161+dk2pm      wk2=-3.447329e-009+dwk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022441816     lkvth0we=0
+ wkvth0we=-3.9000021e-011  pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0006+dcitpm
+ voff=-0.10284852+dvoffpm  wvoff=-7.239391e-010+dwvoffpm
+ nfactor=1                 eta0=0.21+deta0pm         etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.01666
+ ua=2.5815123e-009+duapm   wua=5.3261234e-017+dwuapm ub=4.5310387e-019
+ wub=-4.1135254e-025       uc=5.0685613e-011         wuc=-1.4702858e-017
+ vsat=152900               a0=1.6055703              wa0=2.7837182e-008
+ ags=0.61445071+dagspm     wags=2.8112968e-008       a1=0
+ a2=0.5705                 b0=0                      b1=0
+ keta=-0.040347097         wketa=2.0683974e-009      dwg=0
+ dwb=0                     pclm=0.6509               pdiblc1=0
+ pdiblc2=0.0040607535+dpdiblc2pm                     wpdiblc2=-3.5369596e-010+dwpdiblc2pm
+ pdiblcb=-0.26709677       wpdiblcb=6.4637417e-008   drout=0.5
+ pvag=0.895                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0.017
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=200                  rsw=140                   rdw=140
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=2.593e-009          bgidl=2.5204e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgopm                cgdo=cgopm
+ cgbo=0                    cgdl=cglpm                cgsl=cglpm
+ clc=1e-007                cle=0.6                   cf=cfpm
+ ckappas=0.6               ckappad=0.6               acde=0.3322
+ moin=9.77                 noff=1.919                voffcv=-0.0543
+ kt1=-0.35072              wkt1=8.01504e-009         kt1l=0
+ kt2=-0.01162529           wkt2=-1.5426797e-009      ute=-1.6044
+ wute=2.67168e-008         ua1=2.8553548e-009        wua1=-1.7021187e-016
+ ub1=-1.0301562e-017       wub1=7.3557396e-025       uc1=-3.2532194e-010
+ wuc1=1.3315308e-017       prt=0                     at=338164.52
+ wat=-0.036412417          jss=1.48e-07              jsd=1.48e-07
+ jsws=4.06e-13             jswd=4.06e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.1                  bvd=11.1
+ xjbvs=1                   xjbvd=1                   pbs=0.886
+ pbd=0.886                 cjs=cjpm                  cjd=cjpm
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswpm              cjswd=cjswpm
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgpm            cjswgd=cjswgpm
+ mjswgs=0.70189            mjswgd=0.70189            tpb=0.00161
+ tcj=9.18e-04              tpbsw=0.00125             tcjsw=8.86e-04
+ tpbswg=0.00115            tcjswg=0.00158            xtis=3
+ xtid=3                    jtsswgs=5.4876e-010       jtsswgd=5.4876e-010
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             rshg=8.41                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=5e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=4.8e-008              lku0=2.5e-007
+ wku0=1e-008               pku0=-1e-012              llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lvth0=0+dlvthpm           pvth0=0+dpvthpm
+ lk2=0+dlk2pm              pk2=0+dpk2pm              lcit=0+dlcitpm
+ wcit=0+dwcitpm            pcit=0+dpcitpm            lvoff=0+dlvoffpm
+ pvoff=0+dpvoffpm          lnfactor=0+dlnfactorpm    lua=0+dluapm
+ pua=0+dpuapm              lpclm=0+dlpclmpm          wpclm=0+dwpclmpm
+ ppclm=0+dppclmpm          lpdiblc2=0+dlpdiblc2pm    ppdiblc2=0+dppdiblc2pm
+ leta0=0+dleta0pm          weta0=0+dweta0pm          peta0=0+dpeta0pm
+ lvsat=0+dlvsatpm          wvsat=0+dwvsatpm          pvsat=0+dpvsatpm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noiap_m              noib=noibp_m              noic=noicp_m
+ em=2.10e7                 ef=1.12                   minr=1e-3
 
 
 
     14: type=p 
+ lmin=1.2e-006-(dxlpm+dlmispm)                       lmax=1e-005-(dxlpm+dlmispm)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15991941+(dvthpm+vthmispm)                  lvth0=7.8531116e-009+dlvthpm
+ wvth0=1.3453478e-010+dwvthpm                        pvth0=-3.9184522e-015+dpvthpm
+ k1=0.1926                 k2=0.05288764+dk2pm       lk2=2.350089e-008+dlk2pm
+ wk2=-3.1402997e-009+dwk2pm                          pk2=-3.0606134e-015+dpk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022499999     lkvth0we=5.7999834e-011
+ wkvth0we=-3.9000027e-011  pkvth0we=5.703715e-023    k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00069457444+dcitpm
+ lcit=9.427628e-010+dlcitpm                          wcit=2.2887013e-011+dwcitpm
+ pcit=-2.281486e-016+dpcitpm                         voff=-0.10282458+dvoffpm
+ lvoff=-2.3859414e-010+dlvoffpm                      wvoff=-5.5171432e-010+dwvoffpm
+ pvoff=-1.7168182e-015+dpvoffpm                      nfactor=1.0354654
+ lnfactor=-3.5353605e-007+dlnfactorpm                wnfactor=-8.58263e-009
+ pnfactor=8.5555724e-014   eta0=0.2194338+deta0pm    leta0=-9.4040589e-008+dleta0pm
+ weta0=-2.2829796e-009+dweta0pm                      peta0=2.2757823e-014+dpeta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.016738733            lu0=-7.8485003e-010       wu0=-1.9053439e-011
+ pu0=1.8993371e-016        ua=2.6216564e-009+duapm   lua=-4.0017548e-016+dluapm
+ wua=7.6771918e-017+dwuapm pua=-2.3436565e-022+dpuapm
+ ub=4.5929185e-019         lub=-6.1684697e-026       wub=-4.8537429e-025
+ pub=7.378839e-031         uc=4.2390655e-011         luc=8.2688068e-017
+ wuc=-1.1713814e-017       puc=-2.9796207e-023       vsat=154924.05
+ lvsat=-0.020176661+dlvsatpm                         wvsat=-0.00055729877+dwvsatpm
+ pvsat=5.5554183e-009+dpvsatpm                       a0=1.5816755
+ la0=2.3819534e-007        wa0=4.0499422e-008        pa0=-1.2622321e-013
+ ags=0.61778775+dagspm     lags=-3.326518e-008       wags=2.0958488e-008
+ pags=7.1319251e-014       a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.037983593
+ lketa=-2.356053e-008      wketa=2.0683974e-009      pketa=-1.5237357e-029
+ dwg=0                     dwb=0                     pclm=-0.046001623
+ lpclm=6.9470457e-006+dlpclmpm                       wpclm=1.2901409e-007+dwpclmpm
+ ppclm=-1.2860736e-012+dppclmpm                      pdiblc1=0
+ pdiblc2=0.0043077948+dpdiblc2pm                     lpdiblc2=-2.4626245e-009+dlpdiblc2pm
+ wpdiblc2=-4.6374244e-010+dwpdiblc2pm                ppdiblc2=1.0969955e-015+dppdiblc2pm
+ pdiblcb=-0.2672938        lpdiblcb=1.9640846e-009   wpdiblcb=7.2075697e-008
+ ppdiblcb=-7.4148292e-014  drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.34100308
+ lkt1=-9.68629e-008        wkt1=6.4186708e-009       pkt1=1.5913365e-014
+ kt1l=0                    kt2=-0.0096909005         lkt2=-1.9282915e-008
+ wkt2=-1.1753432e-009      pkt2=-3.661785e-015       ute=-1.6211313
+ lute=1.6678533e-007       wute=2.9062719e-008       pute=-2.3385231e-014
+ ua1=2.6426146e-009        lua1=2.1206954e-015       wua1=-1.1104894e-016
+ pua1=-5.8976412e-022      ub1=-1.0015604e-017       lub1=-2.8505673e-024
+ wub1=6.5695709e-025       pub1=7.8369026e-031       uc1=-3.227112e-010
+ luc1=-2.6025035e-017      wuc1=7.6450508e-018       puc1=5.6523815e-023
+ prt=0                     at=350772.99              lat=-0.12568719
+ wat=-0.039319068          pat=2.8974872e-008        jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     15: type=p 
+ lmin=5e-007-(dxlpm+dlmispm)                         lmax=1.2e-006-(dxlpm+dlmispm)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.1433152+(dvthpm+vthmispm)                   lvth0=-1.1548469e-008+dlvthpm
+ wvth0=-6.4690988e-009+dwvthpm                       pvth0=3.797722e-015+dpvthpm
+ k1=0.1926                 k2=0.081588009+dk2pm      lk2=-1.0034744e-008+dlk2pm
+ wk2=-8.0220446e-009+dwk2pm                          pk2=2.6435785e-015+dpk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022500001     lkvth0we=5.8000108e-011
+ wkvth0we=-3.8999949e-011  pkvth0we=-3.3697623e-023  k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00090240314+dcitpm
+ lcit=-9.2326397e-010+dlcitpm                        wcit=-4.6075645e-010+dwcitpm
+ pcit=3.3697621e-016+dpcitpm                         voff=-0.092510907+dvoffpm
+ lvoff=-1.2289855e-008+dlvoffpm                      wvoff=-4.405982e-009+dwvoffpm
+ pvoff=2.7867933e-015+dpvoffpm                       nfactor=0.55414909
+ lnfactor=2.0886956e-007+dlnfactorpm                 wnfactor=1.0789592e-007
+ pnfactor=-5.0546433e-014  eta0=0.091403658+deta0pm  leta0=5.5559303e-008+dleta0pm
+ weta0=2.8700315e-008+dweta0pm                       peta0=-1.3445351e-014+dpeta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.015670211            lu0=4.6369042e-010        wu0=2.3952894e-010
+ pu0=-1.1221308e-016       ua=1.955542e-009+duapm    lua=3.7816187e-016+dluapm
+ wua=-8.3023857e-017+dwuapm                          pua=-4.7648438e-023+dpuapm
+ ub=2.5816956e-019         lub=1.7332147e-025        wub=1.7438734e-025
+ pub=-3.3030409e-032       uc=2.1126503e-010         luc=-1.1463725e-016
+ wuc=-5.7611742e-017       puc=2.3834328e-023        vsat=127454.84
+ lvsat=0.011920398+dlvsatpm                          wvsat=0.0070060417+dwvsatpm
+ pvsat=-3.2821484e-009+dpvsatpm                      a0=2.5407793
+ la0=-8.8249255e-007       wa0=-2.1134465e-007       pa0=1.6805004e-013
+ ags=0.54536182+dagspm     lags=5.1362639e-008       wags=8.0994008e-008
+ pags=1.1693075e-015       a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.056240386
+ lketa=-2.227942e-009      wketa=1.6069734e-009      pketa=5.3916195e-016
+ dwg=0                     dwb=0                     pclm=9.6737674
+ lpclm=-4.4102517e-006+dlpclmpm                      wpclm=-1.8361479e-006+dwpclmpm
+ ppclm=1.0101671e-012+dppclmpm                       pdiblc1=0
+ pdiblc2=-0.0045649684+dpdiblc2pm                    lpdiblc2=7.9049686e-009+dlpdiblc2pm
+ wpdiblc2=2.1563988e-009+dwpdiblc2pm                 ppdiblc2=-1.9645714e-015+dppdiblc2pm
+ pdiblcb=-0.49972038       lpdiblcb=2.735485e-007    wpdiblcb=1.0090313e-007
+ ppdiblcb=-1.0783239e-013  drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.4812818
+ lkt1=6.7049146e-008       wkt1=4.5358242e-008       pkt1=-2.9586512e-014
+ kt1l=0                    kt2=-0.0259597            lkt2=-2.7324578e-010
+ wkt2=-4.5860157e-009      pkt2=3.2349717e-016       ute=-1.7780485
+ lute=3.5013904e-007       wute=8.431903e-008        pute=-8.7950794e-014
+ ua1=4.1672221e-009        lua1=3.3923113e-016       wua1=-6.247193e-016
+ pua1=1.044633e-023        ub1=-1.3408286e-017       lub1=1.1136935e-024
+ wub1=1.7573538e-024       pub1=-5.0209464e-031      uc1=-4.7008717e-010
+ luc1=1.4617995e-016       wuc1=9.0424027e-017       puc1=-4.0201267e-023
+ prt=0                     at=280686.54              lat=-0.04379299
+ wat=-0.030296814          pat=1.8432603e-008        jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     16: type=p 
+ lmin=2.5e-07              lmax=5e-007-(dxlpm+dlmispm)
+ wmin=2.2e-07              wmax=5.3e-007-(dxwpm+dwmispm)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxpm+toxmispm)     toxm=(toxpm+toxmispm)     dtox=4.896e-010
+ epsrox=3.9                wint=-1.1e-008            lint=8.263e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxlpm+dlmispm)
+ xw=0+(dxwpm+dwmispm)      dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.18140812+(dvthpm+vthmispm)                  lvth0=6.2970702e-009+dlvthpm
+ wvth0=7.4171519e-009+dwvthpm                        pvth0=-2.7076254e-015+dpvthpm
+ k1=0.1926                 k2=0.056367717+dk2pm      lk2=1.7803066e-009+dlk2pm
+ wk2=-4.9795715e-010+dwk2pm                          pk2=-8.8126087e-016+dpk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022650892     lkvth0we=6.5068925e-011
+ wkvth0we=-3.067071e-011   pkvth0we=-3.9020657e-018  k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0023958264+dcitpm
+ lcit=6.2187081e-010+dlcitpm                         wcit=6.0345414e-010+dwcitpm
+ pcit=-1.6157878e-016+dpcitpm                        voff=-0.11914358+dvoffpm
+ lvoff=1.8685885e-010+dlvoffpm                       wvoff=3.8467817e-009+dwvoffpm
+ pvoff=-1.0794119e-015+dpvoffpm                      nfactor=1
+ eta0=0.13511485+deta0pm   leta0=3.5081744e-008+dleta0pm
+ weta0=4.2132546e-008+dweta0pm                       peta0=-1.9738002e-014+dpeta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.017654768            lu0=-4.6602309e-010       wu0=-3.8847604e-010
+ pu0=1.8199092e-016        ua=3.5975652e-009+duapm   lua=-3.9108333e-016+dluapm
+ wua=-4.1337021e-016+dwuapm                          pua=1.0711024e-022+dpuapm
+ ub=-6.7942838e-019        lub=6.1256173e-025        wub=3.3585369e-025
+ pub=-1.086732e-031        uc=-1.5964568e-010        luc=5.9124775e-017
+ wuc=3.4262662e-017        puc=-1.9206441e-023       vsat=144081.64
+ lvsat=0.0041311722+dlvsatpm                         wvsat=0.010482761+dwvsatpm
+ pvsat=-4.910901e-009+dpvsatpm                       a0=0.40280244
+ la0=1.1909401e-007        wa0=1.9218771e-007        pa0=-2.099438e-014
+ ags=0.33665966+dagspm     lags=1.4913417e-007       wags=2.7737587e-007
+ pags=-9.083049e-014       a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.053436542
+ lketa=-3.54147e-009       wketa=-5.4672574e-010     pketa=1.548114e-015
+ dwg=0                     dwb=0                     pclm=-0.14143722
+ lpclm=1.879165e-007+dlpclmpm                        wpclm=5.6982411e-007+dwpclmpm
+ ppclm=-1.1696825e-013+dppclmpm                      pdiblc1=0
+ pdiblc2=0.020213556+dpdiblc2pm                      lpdiblc2=-3.703126e-009+dlpdiblc2pm
+ wpdiblc2=-3.4056526e-009+dwpdiblc2pm                ppdiblc2=6.4110509e-016+dppdiblc2pm
+ pdiblcb=0.28376547        lpdiblcb=-9.3494251e-008  wpdiblcb=-2.5391025e-007
+ ppdiblcb=5.838845e-014    drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.31123593
+ lkt1=-1.2612922e-008      wkt1=-2.9908938e-008      pkt1=5.6742046e-015
+ kt1l=0                    kt2=0.0022795324          lkt2=-1.3502592e-008
+ wkt2=-1.6443239e-008      pkt2=5.8782982e-015       ute=-1.7002527
+ lute=3.1369373e-007       wute=4.6860511e-008       pute=-7.0402452e-014
+ ua1=-1.1665569e-009       lua1=2.8379679e-015       wua1=1.2596353e-015
+ pua1=-8.723248e-022       ub1=-5.2240365e-018       lub1=-2.7204144e-024
+ wub1=-1.3761119e-024      pub1=9.6585254e-031       uc1=-2.296169e-010
+ luc1=3.352588e-017        wuc1=4.2811689e-017       puc1=-1.7896124e-023
+ prt=0                     at=319506.63              lat=-0.061979192
+ wat=0.021132548           pat=-5.6607162e-009       jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  lnfactor=0+dlnfactorpm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noiap_m              noib=noibp_m              noic=noicp_m
+ em=2.10e7                 ef=1.12                   minr=1e-3
 
 
     } 
ends mepch_mac
// 
 
 
// *********************************************************************************************
//                                                                            
//                   *
//                               1.8 V MED-SVT  NMOS DEVICE MODELS            
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
model mench bsim4  { 
     1: type=n 
+ lmin=1e-005-dxlnm         lmax=2.001e-05            wmin=1.003e-005-dxwnm
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.276+dvthnm         k1=0.4215                 k2=0.021275+dk2m
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0024984743      lkvth0we=0
+ wkvth0we=0                pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0004+dcitnm
+ voff=-0.089+dvoffnm       nfactor=1                 eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.03968+du0nm          ua=-8.807e-010            ub=3.208e-018
+ uc=1.918e-010             vsat=88560+dvsatnm        a0=1.806+da0nm
+ ags=0.66052               a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.0674
+ dwg=0                     dwb=0                     pclm=0.8351+dpclmnm
+ pdiblc1=0                 pdiblc2=0.000776+dpdiblc2nm
+ pdiblcb=0.55              drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.20623
+ kt1l=0                    kt2=-0.039870001          ute=-1.7599
+ ua1=5.3952e-010           ub1=-5.1533001e-019       uc1=-2.8145e-010
+ prt=0                     at=30388                  jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 lvth0=0+dlvthnm
+ wvth0=0+dwvthnm           pvth0=0+dpvthnm           lk2=0+dlk2m
+ lcit=0+dlcitnm            pcit=0+dpcitnm            lvoff=0+dlvoffnm
+ pvoff=0+dpvoffnm          lu0=0+dlu0nm              pu0=0+dpu0nm
+ lvsat=0+dlvsatnm          pvsat=0+dpvsatnm          la0=0+dla0nm
+ pa0=0+dpa0nm              lpclm=0+dlpclmnm          ppclm=0+dppclmnm
+ lpdiblc2=0+dlpdiblc2nm    ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     2: type=n 
+ lmin=1.2e-006-dxlnm       lmax=1e-005-dxlnm         wmin=1.003e-005-dxwnm
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.27419524+dvthnm    lvth0=1.7929235e-008+dlvthnm
+ k1=0.4215                 k2=0.021898286+dk2m       lk2=-6.1919893e-009+dlk2m
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0025032258      lkvth0we=-4.7203705e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00037421773+dcitnm
+ lcit=-2.5613193e-010+dlcitnm                        voff=-0.087710886+dvoffnm
+ lvoff=-1.2806596e-008+dlvoffnm                      nfactor=1
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.03968+du0nm          ua=-8.6739635e-010
+ lua=-1.3216407e-016       ub=3.1904552e-018         lub=1.7429778e-025
+ uc=1.918e-010             vsat=86543.826+dvsatnm    lvsat=0.020029517+dlvsatnm
+ a0=1.8640101+da0nm        la0=-5.7629683e-007+dla0nm
+ ags=0.64714416            lags=1.3288124e-007       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.066342927         lketa=-1.0501409e-008     dwg=0
+ dwb=0                     pclm=0.83712391+dpclmnm   lpclm=-2.0106356e-008+dlpclmnm
+ pdiblc1=0                 pdiblc2=0.00050956599+dpdiblc2nm
+ lpdiblc2=2.6468673e-009+dlpdiblc2nm                 pdiblcb=0.56289114
+ lpdiblcb=-1.2806595e-007  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.20141258
+ lkt1=-4.785825e-008       kt1l=0                    kt2=-0.039432992
+ lkt2=-4.3414349e-009      ute=-1.7475632            lute=-1.2255913e-007
+ ua1=4.7832835e-010        lua1=6.0790351e-016       ub1=-3.5875814e-019
+ lub1=-1.5554508e-024      uc1=-3.1257565e-010       luc1=3.0921527e-016
+ prt=0                     at=30388                  jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 wvth0=0+dwvthnm
+ pvth0=0+dpvthnm           pcit=0+dpcitnm            pvoff=0+dpvoffnm
+ lu0=0+dlu0nm              pu0=0+dpu0nm              pvsat=0+dpvsatnm
+ pa0=0+dpa0nm              ppclm=0+dppclmnm          ppdiblc2=0+dppdiblc2nm
+ leta0=0+dleta0nm          peta0=0+dpeta0nm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noian_m
+ noib=noibn_m              noic=noicn_m              em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     3: type=n 
+ lmin=5e-007-dxlnm         lmax=1.2e-006-dxlnm       wmin=1.003e-005-dxwnm
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.2924824+dvthnm     lvth0=-2.8160842e-009+dlvthnm
+ k1=0.4215                 k2=0.016713064+dk2m       lk2=-3.0976926e-010+dlk2m
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0025032258      lkvth0we=-4.7203626e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00078618+dcitnm
+ lcit=2.1120632e-010+dlcitnm                         voff=-0.10244433+dvoffnm
+ lvoff=3.9073168e-009+dlvoffnm                       nfactor=1
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.03968+du0nm          ua=-9.981738e-010
+ lua=1.6192484e-017        ub=3.2418872e-018         lub=1.1595227e-025
+ uc=1.8081538e-010         luc=1.2461173e-017        vsat=108358.02+dvsatnm
+ lvsat=-0.004716941+dlvsatnm                         a0=1.2653924+da0nm
+ la0=1.0278707e-007+dla0nm ags=0.90166843            lags=-1.5585618e-007
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.08466076          lketa=1.0278707e-008
+ dwg=0                     dwb=0                     pclm=0.73180852+dpclmnm
+ lpclm=9.9365531e-008+dlpclmnm                       pdiblc1=0
+ pdiblc2=0.0021294203+dpdiblc2nm                     lpdiblc2=8.092722e-010+dlpdiblc2nm
+ pdiblcb=0.79133002        lpdiblcb=-3.8721159e-007  drout=0.5
+ pvag=1.787                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=78.59                 rdw=78.59
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=1e-008              bgidl=2.2849e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgonm                cgdo=cgonm
+ cgbo=0                    cgdl=cglnm                cgsl=cglnm
+ clc=1e-007                cle=0.6                   cf=cfnm
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=1.586                voffcv=0.0135
+ kt1=-0.23664928           lkt1=-7.8850358e-009      kt1l=0
+ kt2=-0.047715908          lkt2=5.0548712e-009       ute=-1.82246
+ lute=-3.7594724e-008      ua1=1.0168065e-009        lua1=-2.9568884e-018
+ ub1=-1.7298379e-018       lub1=-7.0402105e-029      uc1=-3.672323e-011
+ luc1=-3.7172319e-018      prt=0                     at=30299.875
+ lat=9.9970989e-005        jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 wvth0=0+dwvthnm           pvth0=0+dpvthnm
+ pcit=0+dpcitnm            pvoff=0+dpvoffnm          lu0=0+dlu0nm
+ pu0=0+dpu0nm              pvsat=0+dpvsatnm          pa0=0+dpa0nm
+ ppclm=0+dppclmnm          ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     4: type=n 
+ lmin=2.85e-07             lmax=5e-007-dxlnm         wmin=1.003e-005-dxwnm
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.2918605+dvthnm     lvth0=-2.5459184e-009+dlvthnm
+ k1=0.4215                 k2=0.0034597021+dk2m      lk2=5.4477562e-009+dlk2m
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0025193604      lkvth0we=-5.4212838e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0003+dcitnm
+ voff=-0.10072991+dvoffnm  lvoff=3.1625398e-009+dlvoffnm
+ nfactor=1                 eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.041282261+du0nm
+ lu0=-6.9605409e-010+dlu0nm                          ua=-1.1847477e-009
+ lua=9.72439e-017          ub=4.3774433e-018         lub=-3.7735603e-025
+ uc=2.294257e-010          luc=-8.6561226e-018       vsat=114367.69+dvsatnm
+ lvsat=-0.0073276624+dlvsatnm                        a0=1.8412057+da0nm
+ la0=-1.4735776e-007+dla0nm                          ags=0.82232864
+ lags=-1.2138939e-007      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.082808093
+ lketa=9.4738716e-009      dwg=0                     dwb=0
+ pclm=0.76050941+dpclmnm   lpclm=8.6897287e-008+dlpclmnm
+ pdiblc1=0                 pdiblc2=0.00059637467+dpdiblc2nm
+ lpdiblc2=1.4752579e-009+dlpdiblc2nm                 pdiblcb=0.034614419
+ lpdiblcb=-5.8479196e-008  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.2752614
+ lkt1=8.8888399e-009       kt1l=0                    kt2=-0.041356886
+ lkt2=2.2923847e-009       ute=-2.2980357            lute=1.6900489e-007
+ ua1=-1.1699197e-010       lua1=4.8958785e-016       ub1=-3.9274033e-019
+ lub1=-5.8093235e-025      uc1=-4.6572299e-011       luc1=5.6140047e-019
+ prt=0                     at=31243.456              lat=-0.0003099396
+ jss=2.34e-07              jsd=2.34e-07              jsws=7.68e-13
+ jswd=7.68e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.3                  bvd=11.3                  xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjnm                  cjd=cjnm                  mjs=0.333
+ mjd=0.333                 pbsws=0.29                pbswd=0.29
+ cjsws=cjswnm              cjswd=cjswnm              mjsws=0.146
+ mjswd=0.146               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgnm            cjswgd=cjswgnm            mjswgs=0.713
+ mjswgd=0.713              tpb=0.00149               tcj=0.000913
+ tpbsw=0.001               tcjsw=0.000765            tpbswg=0.00115
+ tcjswg=0.00083            xtis=3                    xtid=3
+ jtsswgs=3.9893e-010       jtsswgd=3.9893e-010       njtsswg=17.974
+ xtsswgs=0.30393           xtsswgd=0.30393           tnjtsswg=0
+ vtsswgs=11.126            vtsswgd=11.126            dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rshg=8.23                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-4e-008               lku0=2e-007               wku0=2e-006
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ wvth0=0+dwvthnm           pvth0=0+dpvthnm           lcit=0+dlcitnm
+ pcit=0+dpcitnm            pvoff=0+dpvoffnm          pu0=0+dpu0nm
+ pvsat=0+dpvsatnm          pa0=0+dpa0nm              ppclm=0+dppclmnm
+ ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     5: type=n 
+ lmin=1e-005-dxlnm         lmax=2.001e-05            wmin=1.23e-006-dxwnm
+ wmax=1.003e-005-dxwnm     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.27338102+dvthnm    wvth0=2.6223819e-008+dwvthnm
+ k1=0.4215                 k2=0.021428693+dk2m       wk2=-1.5389241e-009
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.002494967       lkvth0we=0
+ wkvth0we=3.5118525e-011   pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00037243182+dcitnm
+ wcit=-2.760402e-010       voff=-0.087208068+dvoffnm wvoff=-1.7942613e-008
+ nfactor=1.0137841         wnfactor=-1.380201e-007   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.03968+du0nm          ua=-9.409475e-010         wua=6.0325826e-016
+ ub=3.3301408e-018         wub=-1.2229961e-024       uc=1.9549414e-010
+ wuc=-3.6989387e-017       vsat=88624.785+dvsatnm    wvsat=-0.00064869448
+ a0=1.8479036+da0nm        wa0=-4.1958111e-007       ags=0.66676281
+ wags=-6.2509304e-008      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.068282182
+ wketa=8.8332865e-009      dwg=0                     dwb=0
+ pclm=0.8839453+dpclmnm    wpclm=-4.8908803e-007     pdiblc1=0
+ pdiblc2=0.00075165316+dpdiblc2nm                    wpdiblc2=2.4378491e-010
+ pdiblcb=0.55              drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.2001967
+ wkt1=-6.0411399e-008      kt1l=0                    kt2=-0.039981652
+ wkt2=1.1179628e-009       ute=-1.7858003            wute=2.5933977e-007
+ ua1=3.6890328e-010        wua1=1.7083852e-015       ub1=-2.0437884e-019
+ wub1=-3.1135541e-024      uc1=-3.0500012e-010       wuc1=2.3580734e-016
+ prt=0                     at=9241.5505              wat=0.2117394
+ jss=2.34e-07              jsd=2.34e-07              jsws=7.68e-13
+ jswd=7.68e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.3                  bvd=11.3                  xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjnm                  cjd=cjnm                  mjs=0.333
+ mjd=0.333                 pbsws=0.29                pbswd=0.29
+ cjsws=cjswnm              cjswd=cjswnm              mjsws=0.146
+ mjswd=0.146               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgnm            cjswgd=cjswgnm            mjswgs=0.713
+ mjswgd=0.713              tpb=0.00149               tcj=0.000913
+ tpbsw=0.001               tcjsw=0.000765            tpbswg=0.00115
+ tcjswg=0.00083            xtis=3                    xtid=3
+ jtsswgs=3.9893e-010       jtsswgd=3.9893e-010       njtsswg=17.974
+ xtsswgs=0.30393           xtsswgd=0.30393           tnjtsswg=0
+ vtsswgs=11.126            vtsswgd=11.126            dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rshg=8.23                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-4e-008               lku0=2e-007               wku0=2e-006
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ lvth0=0+dlvthnm           pvth0=0+dpvthnm           lk2=0+dlk2m
+ lcit=0+dlcitnm            pcit=0+dpcitnm            lvoff=0+dlvoffnm
+ pvoff=0+dpvoffnm          lu0=0+dlu0nm              pu0=0+dpu0nm
+ lvsat=0+dlvsatnm          pvsat=0+dpvsatnm          la0=0+dla0nm
+ pa0=0+dpa0nm              lpclm=0+dlpclmnm          ppclm=0+dppclmnm
+ lpdiblc2=0+dlpdiblc2nm    ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     6: type=n 
+ lmin=1.2e-006-dxlnm       lmax=1e-005-dxlnm         wmin=1.23e-006-dxwnm
+ wmax=1.003e-005-dxwnm     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.27145188+dvthnm    lvth0=1.9164926e-008+dlvthnm
+ wvth0=2.7469285e-008+dwvthnm                        pvth0=-1.2372974e-014+dpvthnm
+ k1=0.4215                 k2=0.022010666+dk2m       lk2=-5.7815634e-009+dlk2m
+ wk2=-1.1252518e-009       pk2=-4.109595e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025            lkvth0we=-5.0000074e-011  wkvth0we=3.2300037e-011
+ pkvth0we=2.800004e-017    k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00033954184+dcitnm lcit=-3.2674284e-010+dlcitnm
+ wcit=-3.4720964e-010      pcit=7.0702709e-016+dpcitnm
+ voff=-0.085913801+dvoffnm lvoff=-1.2857789e-008+dlvoffnm
+ wvoff=-1.7994211e-008     pvoff=5.1259464e-016+dpvoffnm
+ nfactor=1.0137841         wnfactor=-1.380201e-007   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.039665891+du0nm      lu0=1.4016267e-010+dlu0nm wu0=1.4127134e-010
+ pu0=-1.4034488e-015+dpu0nm                          ua=-9.2452375e-010
+ lua=-1.631605e-016        wua=5.7201666e-016        pua=3.1036722e-022
+ ub=3.3054279e-018         lub=2.4550888e-025        wub=-1.1512217e-024
+ pub=-7.1303682e-031       uc=1.9491912e-010         luc=5.712423e-018
+ wuc=-3.123178e-017        puc=-5.7198492e-023       vsat=86337.115+dvsatnm
+ lvsat=0.022726677+dlvsatnm                          wvsat=0.0020698001
+ pvsat=-2.7006667e-008+dpvsatnm                      a0=1.9060204+da0nm
+ la0=-5.77356e-007+dla0nm  wa0=-4.2064865e-007       pa0=1.0605406e-014+dpa0nm
+ ags=0.65550169            lags=1.1187273e-007       wags=-8.3683991e-008
+ pags=2.1035824e-013       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.067310401
+ lketa=-9.654078e-009      wketa=9.6873198e-009      pketa=-8.4843251e-015
+ dwg=0                     dwb=0                     pclm=0.89796275+dpclmnm
+ lpclm=-1.3925521e-007+dlpclmnm                      wpclm=-6.0917934e-007
+ ppclm=1.1930375e-012+dppclmnm                       pdiblc1=0
+ pdiblc2=0.00047559834+dpdiblc2nm                    lpdiblc2=2.7424445e-009+dlpdiblc2nm
+ wpdiblc2=3.4011808e-010   ppdiblc2=-9.570142e-016+dppdiblc2nm
+ pdiblcb=0.56200267        lpdiblcb=-1.1923958e-007  wpdiblcb=8.8961816e-009
+ ppdiblcb=-8.8378404e-014  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.19449669
+ lkt1=-5.6626361e-008      wkt1=-6.9248864e-008      pkt1=8.7795089e-014
+ kt1l=0                    kt2=-0.039442825          lkt2=-5.352936e-009
+ wkt2=9.8460802e-011       pkt2=1.0128161e-014       ute=-1.7706328
+ lute=-1.5067992e-007      wute=2.3099654e-007       pute=2.8157354e-013
+ ua1=2.8813026e-010        lua1=8.0243305e-016       wua1=1.9044535e-015
+ pua1=-1.9478243e-021      ub1=1.9010069e-020        lub1=-2.2192392e-024
+ wub1=-3.782593e-024       pub1=6.6465141e-030       uc1=-3.4227393e-010
+ luc1=3.7029371e-016       wuc1=2.9736891e-016       puc1=-6.1157844e-022
+ prt=0                     at=8245.2281              lat=0.009897885
+ wat=0.22171558            pat=-9.9107523e-008       jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     7: type=n 
+ lmin=5e-007-dxlnm         lmax=1.2e-006-dxlnm       wmin=1.23e-006-dxwnm
+ wmax=1.003e-005-dxwnm     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29048613+dvthnm    lvth0=-2.4279126e-009+dlvthnm
+ wvth0=1.9988623e-008+dwvthnm                        pvth0=-3.8867623e-015+dpvthnm
+ k1=0.4215                 k2=0.017481508+dk2m       lk2=-6.4359685e-010+dlk2m
+ wk2=-7.694433e-009        pk2=3.3426156e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0024999999      lkvth0we=-4.9999985e-011  wkvth0we=3.2300122e-011
+ pkvth0we=2.7999944e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00084796581+dcitnm lcit=2.5002348e-010+dlcitnm
+ wcit=6.1866131e-010       pcit=-3.8867623e-016+dpcitnm
+ voff=-0.10084207+dvoffnm  lvoff=4.0771419e-009+dlvoffnm
+ wvoff=-1.6043388e-008     pvoff=-1.7004585e-015+dpvoffnm
+ nfactor=1.0137841         wnfactor=-1.380201e-007   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.039280972+du0nm      lu0=5.7682301e-010+dlu0nm wu0=3.99547e-009
+ pu0=-5.7757288e-015+dpu0nm                          ua=-1.1448555e-009
+ lua=8.6788284e-017        wua=1.4687242e-015        pua=-7.0687574e-022
+ ub=3.4685471e-018         lub=6.0463136e-026        wub=-2.2695461e-024
+ pub=5.5561267e-031        uc=1.9072028e-010         luc=1.0475675e-017
+ wuc=-9.9177762e-017       puc=1.9880789e-023        vsat=111054.63+dvsatnm
+ lvsat=-0.0053133667+dlvsatnm                        wvsat=-0.027001159
+ pvsat=5.9720103e-009+dpvsatnm                       a0=1.2635259+da0nm
+ la0=1.5150261e-007+dla0nm wa0=1.8689578e-008        pa0=-4.8778867e-013+dpa0nm
+ ags=0.90734442            lags=-1.738227e-007       wags=-5.6833758e-008
+ pags=1.7989879e-013       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.084881305
+ lketa=1.0278707e-008      wketa=2.2083216e-009      pketa=4.0947392e-030
+ dwg=0                     dwb=0                     pclm=0.66527774+dpclmnm
+ lpclm=1.2470731e-007+dlpclmnm                       wpclm=6.6617263e-007
+ ppclm=-2.5374728e-013+dppclmnm                      pdiblc1=0
+ pdiblc2=0.0022723574+dpdiblc2nm                     lpdiblc2=7.0416503e-010+dlpdiblc2nm
+ wpdiblc2=-1.4312296e-009  ppdiblc2=1.0524381e-015+dppdiblc2nm
+ pdiblcb=0.80249927        lpdiblcb=-3.9206373e-007  wpdiblcb=-1.118377e-007
+ ppdiblcb=4.8584529e-014   drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.23605962
+ lkt1=-9.4765394e-009      wkt1=-5.9042791e-009      pkt1=1.5935725e-014
+ kt1l=0                    kt2=-0.049574625          lkt2=6.1407811e-009
+ wkt2=1.8611338e-008       pkt2=-1.0873217e-014      ute=-1.8771105
+ lute=-2.9889518e-008      wute=5.4721608e-007       pute=-7.7152232e-014
+ ua1=1.0314157e-009        lua1=-4.0764803e-017      wua1=-1.4628165e-016
+ pua1=3.7857065e-022       ub1=-2.12351e-018         lub1=2.1127835e-025
+ wub1=3.9418381e-024       pub1=-2.116235e-030       uc1=-8.052542e-013
+ luc1=-1.7075187e-017      wuc1=-3.596467e-016       puc1=1.3375321e-022
+ prt=0                     at=8509.7956              lat=0.0095977544
+ wat=0.21818406            pat=-9.5101305e-008       jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     8: type=n 
+ lmin=2.85e-07             lmax=5e-007-dxlnm         wmin=1.23e-006-dxwnm
+ wmax=1.003e-005-dxwnm     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29124246+dvthnm    lvth0=-2.7564774e-009+dlvthnm
+ wvth0=6.1884073e-009+dwvthnm                        pvth0=2.1083275e-015+dpvthnm
+ k1=0.4215                 k2=0.0037721656+dk2m      lk2=5.3120158e-009+dlk2m
+ wk2=-3.1286968e-009       pk2=1.3591685e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025170904      lkvth0we=-5.7424431e-011  wkvth0we=2.2729331e-011
+ pkvth0we=3.2157687e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00027627864+dcitnm lcit=1.6711368e-012+dlcitnm
+ wcit=-2.3752197e-010      pcit=-1.6733093e-017+dpcitnm
+ voff=-0.10021197+dvoffnm  lvoff=3.8034113e-009+dlvoffnm
+ wvoff=-5.1861811e-009     pvoff=-6.4170462e-015+dpvoffnm
+ nfactor=1.0323316         lnfactor=-8.057392e-009   wnfactor=-3.2373592e-007
+ pnfactor=8.0678666e-014   eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.043125481+du0nm
+ lu0=-1.0933088e-009+dlu0nm                          wu0=-1.8456167e-008
+ pu0=3.9777112e-015+dpu0nm ua=-1.1040138e-009        lua=6.9045835e-017
+ wua=-8.0838774e-016       pua=2.8234722e-022        ub=4.462348e-018
+ lub=-3.7126385e-025       wub=-8.50151e-025         pub=-6.1000943e-032
+ uc=2.2949156e-010         luc=-6.367346e-018        wuc=-6.5948627e-019
+ puc=-2.291752e-023        vsat=117299.26+dvsatnm    lvsat=-0.0080261568+dlvsatnm
+ wvsat=-0.029353755        pvsat=6.9940251e-009+dpvsatnm
+ a0=2.0720855+da0nm        la0=-1.9975186e-007+dla0nm
+ wa0=-2.311799e-006        pa0=5.2462216e-013+dpa0nm ags=0.80332371
+ lags=-1.2863402e-007      wags=1.9029637e-007       pags=7.2540522e-014
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.087519129         lketa=1.1424631e-008
+ wketa=4.717161e-008       pketa=-1.9532952e-014     dwg=0
+ dwb=0                     pclm=0.75849158+dpclmnm   lpclm=8.4213361e-008+dlpclmnm
+ wpclm=2.0204619e-008      ppclm=2.6874148e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=7.7815891e-005+dpdiblc2nm
+ lpdiblc2=1.6575178e-009+dlpdiblc2nm                 wpdiblc2=5.1923291e-009
+ ppdiblc2=-1.8249683e-015+dppdiblc2nm                pdiblcb=0.053169796
+ lpdiblcb=-6.6540022e-008  wpdiblcb=-1.8579499e-007  ppdiblcb=8.0713053e-014
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.28789127           lkt1=1.3040165e-008
+ wkt1=1.264629e-007        pkt1=-4.1567223e-014      kt1l=0
+ kt2=-0.041254031          lkt2=2.5261486e-009       wkt2=-1.0298804e-009
+ pkt2=-2.3406786e-015      ute=-2.3312013            lute=1.673766e-007
+ wute=3.3208722e-007       pute=1.6304048e-014       ua1=8.3610142e-011
+ lua1=3.7098088e-016       wua1=-2.0086289e-015      pua1=1.1876115e-021
+ ub1=-6.9645147e-019       lub1=-4.0866441e-025      wub1=3.0410597e-024
+ pub1=-1.7249189e-030      uc1=-3.8037319e-011       luc1=-9.0083335e-019
+ wuc1=-8.546075e-017       puc1=1.4641347e-023       prt=0
+ at=30583.576              lat=8.4627059e-006        wat=0.0066073804
+ pat=-3.1881623e-009       jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     9: type=n 
+ lmin=1e-005-dxlnm         lmax=2.001e-05            wmin=5.3e-007-dxwnm
+ wmax=1.23e-006-dxwnm      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29426714+dvthnm    wvth0=8.8895571e-010+dwvthnm
+ k1=0.4215                 k2=0.021742971+dk2m       wk2=-1.9201443e-009
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0024949671      lkvth0we=0
+ wkvth0we=3.5118462e-011   pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00052671429+dcitnm
+ wcit=-8.8895571e-011      voff=-0.094671429+dvoffnm wvoff=-8.8895571e-009
+ nfactor=0.82671429        wnfactor=8.8895571e-008   eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.041631599+du0nm      wu0=-2.3672891e-009       ua=-4.5759559e-010
+ wua=1.6952385e-017        ub=2.6922127e-018         wub=-4.4918932e-025
+ uc=1.8713229e-010         wuc=-2.6846463e-017       vsat=87745.557+dvsatnm
+ wvsat=0.00041780919       a0=1.7233229+da0nm        wa0=-2.6846463e-007
+ ags=0.65677567            wags=-5.0394899e-008      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.063345143         wketa=2.8446583e-009      dwg=0
+ dwb=0                     pclm=0.17038966+dpclmnm   wpclm=3.7645497e-007
+ pdiblc1=0                 pdiblc2=0.0010820746+dpdiblc2nm
+ wpdiblc2=-1.5701625e-010  pdiblcb=0.58664286        wpdiblcb=-4.4447786e-008
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.26890771           wkt1=2.2935057e-008
+ kt1l=0                    kt2=-0.039060001          ute=-1.5148371
+ wute=-6.9338546e-008      ua1=1.9415333e-009        wua1=-1.9921498e-016
+ ub1=-2.527525e-018        wub1=-2.9557778e-025      uc1=-9.9020857e-011
+ wuc1=-1.40455e-017        prt=0                     at=181235
+ wat=0.003111345           jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 lvth0=0+dlvthnm           pvth0=0+dpvthnm
+ lk2=0+dlk2m               lcit=0+dlcitnm            pcit=0+dpcitnm
+ lvoff=0+dlvoffnm          pvoff=0+dpvoffnm          lu0=0+dlu0nm
+ pu0=0+dpu0nm              lvsat=0+dlvsatnm          pvsat=0+dpvsatnm
+ la0=0+dla0nm              pa0=0+dpa0nm              lpclm=0+dlpclmnm
+ ppclm=0+dppclmnm          lpdiblc2=0+dlpdiblc2nm    ppdiblc2=0+dppdiblc2nm
+ leta0=0+dleta0nm          peta0=0+dpeta0nm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noian_m
+ noib=noibn_m              noic=noicn_m              em=4.10e7
+ ef=0.98                   minr=1e-3
 
 
 
     10: type=n 
+ lmin=1.2e-006-dxlnm       lmax=1e-005-dxlnm         wmin=5.3e-007-dxwnm
+ wmax=1.23e-006-dxwnm      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.29345924+dvthnm    lvth0=8.0260768e-009+dlvthnm
+ wvth0=7.7435922e-010+dwvthnm                        pvth0=1.1384497e-015+dpvthnm
+ k1=0.4215                 k2=0.022862482+dk2m       lk2=-1.1121687e-008+dlk2m
+ wk2=-2.158505e-009        pk2=2.3679754e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025000001      lkvth0we=-5.0000087e-011  wkvth0we=3.2299973e-011
+ pkvth0we=2.8000056e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00057139128+dcitnm lcit=4.4384004e-010+dlcitnm
+ wcit=-6.5976273e-011      pcit=-2.2768994e-016+dpcitnm
+ voff=-0.092826405+dvoffnm lvoff=-1.832924e-008+dlvoffnm
+ wvoff=-9.6092231e-009     pvoff=7.1494641e-015+dpvoffnm
+ nfactor=0.81726692        lnfactor=9.3854056e-008   wnfactor=1.0035522e-007
+ pnfactor=-1.1384497e-013  eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.041985537+du0nm
+ lu0=-3.5161772e-009+dlu0nm                          wu0=-2.6724595e-009
+ pu0=3.0316915e-015+dpu0nm ua=-4.6166058e-010        lua=4.0383315e-017
+ wua=1.0563631e-017        pua=6.3468571e-023        ub=2.7443089e-018
+ lub=-5.1754584e-025       wub=-4.7058449e-025       pub=2.1254856e-031
+ uc=1.9464444e-010         luc=-7.462894e-017        wuc=-3.0898595e-017
+ puc=4.0255581e-023        vsat=89157.598+dvsatnm    lvsat=-0.01402781+dlvsatnm
+ wvsat=-0.0013514461       pvsat=1.7576525e-008+dpvsatnm
+ a0=1.8036111+da0nm        la0=-7.9761677e-007+dla0nm
+ wa0=-2.9642617e-007       pa0=2.7778173e-013+dpa0nm ags=0.61714733
+ lags=3.9368459e-007       wags=-3.716015e-008       pags=-1.3147956e-013
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.061971611         lketa=-1.3645245e-008
+ wketa=3.2113671e-009      pketa=-3.643039e-015      dwg=0
+ dwb=0                     pclm=0.026945169+dpclmnm  lpclm=1.4250378e-006+dlpclmnm
+ wpclm=4.4736498e-007      ppclm=-7.044499e-013+dppclmnm
+ pdiblc1=0                 pdiblc2=0.00091815608+dpdiblc2nm
+ lpdiblc2=1.628435e-009+dlpdiblc2nm                  wpdiblc2=-1.9670445e-010
+ ppdiblc2=3.9427928e-016+dppdiblc2nm                 pdiblcb=0.61070324
+ lpdiblcb=-2.3902597e-007  wpdiblcb=-5.017761e-008   ppdiblcb=5.6922485e-014
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.27448956           lkt1=5.5452379e-008
+ wkt1=2.7782489e-008       pkt1=-4.8156422e-014      kt1l=0
+ kt2=-0.039437232          lkt2=3.747576e-009        wkt2=9.1677195e-011
+ pkt2=-9.1075976e-016      ute=-1.4868147            lute=-2.783865e-007
+ wute=-1.1327484e-007      pute=4.3648161e-013       ua1=2.3065855e-009
+ lua1=-3.6265816e-015      wua1=-5.4393269e-016      pua1=3.4245705e-021
+ ub1=-3.3272102e-018       lub1=7.9444089e-024       wub1=2.7637218e-025
+ pub1=-5.6819911e-030      uc1=-7.9407113e-011       luc1=-1.9485117e-016
+ wuc1=-2.1488543e-017      puc1=7.3942308e-023       prt=0
+ at=177694.01              lat=0.035177655           wat=0.0161742
+ pat=-1.2977188e-007       jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     11: type=n 
+ lmin=5e-007-dxlnm         lmax=1.2e-006-dxlnm       wmin=5.3e-007-dxwnm
+ wmax=1.23e-006-dxwnm      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.3059539+dvthnm     lvth0=-6.1481153e-009+dlvthnm
+ wvth0=1.2262255e-009+dwvthnm                        pvth0=6.2584354e-016+dpvthnm
+ k1=0.4215                 k2=0.0098778763+dk2m      lk2=3.608309e-009+dlk2m
+ wk2=1.5287727e-009        pk2=-1.8149463e-015       k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025            lkvth0we=-5.0000022e-011  wkvth0we=3.2300032e-011
+ pkvth0we=2.799999e-017    k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-2.7120629e-005+dcitnm
+ lcit=-1.7359148e-010+dlcitnm                        wcit=-3.770239e-010
+ pcit=1.2516871e-016+dpcitnm                         voff=-0.11439383+dvoffnm
+ lvoff=6.1372834e-009+dlvoffnm                       wvoff=3.9489724e-010
+ pvoff=-4.1994101e-015+dpvoffnm                      nfactor=0.85451889
+ lnfactor=5.1594686e-008   wnfactor=5.5168592e-008   pnfactor=-6.2584354e-014
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.042439313+du0nm      lu0=-4.030949e-009+dlu0nm
+ wu0=1.644024e-010         pu0=-1.8650137e-016+dpu0nm
+ ua=2.1769743e-011         lua=-5.0802971e-016       wua=5.3607733e-017
+ pua=1.463848e-023         ub=1.6822931e-018         lub=6.8722613e-025
+ wub=-1.0282e-025          pub=-2.0465084e-031       uc=7.1647684e-011
+ luc=6.4901046e-017        wuc=4.5257297e-017        puc=-4.6137186e-023
+ vsat=70093.492+dvsatnm    lvsat=0.0075988935+dlvsatnm
+ wvsat=0.022684701         pvsat=-9.6905613e-009+dpvsatnm
+ a0=1.3469087+da0nm        la0=-2.7952452e-007+dla0nm
+ wa0=-8.2453843e-008       pa0=3.5047238e-014+dpa0nm ags=0.90295225
+ lags=6.9461774e-008       wags=-5.1506051e-008      pags=-1.1520528e-013
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.081514402         lketa=8.524488e-009
+ wketa=-1.8757321e-009     pketa=2.127868e-015       dwg=0
+ dwb=0                     pclm=1.4050176+dpclmnm    lpclm=-1.3827515e-007+dlpclmnm
+ wpclm=-2.3113182e-007     ppclm=6.5250447e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=0.0014254861+dpdiblc2nm
+ lpdiblc2=1.0529096e-009+dlpdiblc2nm                 wpdiblc2=-4.0397474e-010
+ ppdiblc2=6.2941085e-016+dppdiblc2nm                 pdiblcb=0.71030001
+ lpdiblcb=-3.5201053e-007  drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.22260406
+ lkt1=-3.4075676e-009      wkt1=-2.2225872e-008      pkt1=8.5740627e-015
+ kt1l=0                    kt2=-0.029856533          lkt2=-7.120961e-009
+ wkt2=-5.3067083e-009      pkt2=5.2132767e-015       ute=-1.6312426
+ lute=-1.1454463e-007      wute=2.4897829e-007       pute=2.5534416e-014
+ ua1=-1.578534e-009        lua1=7.8077564e-016       wua1=3.0195874e-015
+ pua1=-6.1795791e-022      ub1=6.4433307e-018        lub1=-3.1394881e-024
+ wub1=-6.4497397e-024      pub1=1.9482447e-030       uc1=-3.6118503e-010
+ luc1=1.2480333e-016       wuc1=7.7493971e-017       puc1=-3.8345435e-023
+ prt=0                     at=319606.71              lat=-0.12581095
+ wat=-0.1591765            pat=6.9149456e-008        jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     12: type=n 
+ lmin=2.85e-07             lmax=5e-007-dxlnm         wmin=5.3e-007-dxwnm
+ wmax=1.23e-006-dxwnm      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.28895738+dvthnm    lvth0=1.2355124e-009+dlvthnm
+ wvth0=8.9602149e-009+dwvthnm                        pvth0=-2.7339561e-015+dpvthnm
+ k1=0.4215                 k2=0.0053696129+dk2m      lk2=5.5667888e-009+dlk2m
+ wk2=-5.0664004e-009       pk2=1.0501288e-015        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025170904      lkvth0we=-5.7424447e-011  wkvth0we=2.2729301e-011
+ pkvth0we=3.2157706e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00018104609+dcitnm lcit=-1.0672318e-010+dlcitnm
+ wcit=-3.5303905e-010      pcit=1.1474921e-016+dpcitnm
+ voff=-0.083666986+dvoffnm lvoff=-7.2110739e-009+dlvoffnm
+ wvoff=-2.5255244e-008     pvoff=6.9435243e-015+dpvoffnm
+ nfactor=0.93742565        lnfactor=1.5578329e-008   wnfactor=-2.0861505e-007
+ pnfactor=5.2008536e-014   eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.030598998+du0nm
+ lu0=1.1127206e-009+dlu0nm wu0=-3.2615426e-009       pu0=1.3017977e-015+dpu0nm
+ ua=-1.9857284e-009        lua=3.6406763e-016        wua=2.6113202e-016
+ pua=-7.5514222e-023       ub=5.1749416e-018         lub=-8.3005022e-025
+ wub=-1.714527e-024        pub=4.9550692e-031        uc=3.6586384e-010
+ luc=-6.2912335e-017       wuc=-1.6607905e-016       puc=4.5671552e-023
+ vsat=100651.61+dvsatnm    lvsat=-0.0056761629+dlvsatnm
+ wvsat=-0.0091601583       pvsat=4.1434825e-009+dpvsatnm
+ a0=0.44652432+da0nm       la0=1.1162048e-007+dla0nm wa0=-3.3999326e-007
+ pa0=1.4692751e-013+dpa0nm ags=1.480447              lags=-1.8141349e-007
+ wags=-6.3105417e-007      pags=1.3656201e-013       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.049741217         lketa=-5.2784192e-009     wketa=1.3470019e-009
+ pketa=7.2784792e-016      dwg=0                     dwb=0
+ pclm=0.93364125+dpclmnm   lpclm=6.6500174e-008+dlpclmnm
+ wpclm=-1.9225193e-007     ppclm=4.8360244e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=0.0033513003+dpdiblc2nm
+ lpdiblc2=2.1629745e-010+dlpdiblc2nm                 wpdiblc2=1.2215924e-009
+ ppdiblc2=-7.676804e-017+dppdiblc2nm                 pdiblcb=-0.19865316
+ lpdiblcb=4.2856902e-008   wpdiblcb=1.1966626e-007   ppdiblcb=-5.1985415e-014
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.13995135           lkt1=-3.9313558e-008
+ wkt1=-5.2988223e-008      pkt1=2.1937843e-014       kt1l=0
+ kt2=-0.043566837          lkt2=-1.1649308e-009      wkt2=1.775553e-009
+ pkt2=2.1366007e-015       ute=-2.8618248            lute=4.200449e-007
+ wute=9.7573355e-007       pute=-2.901826e-013       ua1=-6.540704e-009
+ lua1=2.9364415e-015       wua1=6.0266642e-015       pua1=-1.9242922e-021
+ ub1=8.3094766e-018        lub1=-3.9501792e-024      wub1=-7.8831311e-024
+ pub1=2.5709386e-030       uc1=-6.4291305e-011       luc1=-4.1732417e-018
+ wuc1=-5.3614665e-017      puc1=1.8610779e-023       prt=0
+ at=30585.058              lat=-0.00025416397        wat=0.0066055828
+ pat=-2.8695961e-009       jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     13: type=n 
+ lmin=1e-005-dxlnm         lmax=2.001e-05            wmin=2.2e-07
+ wmax=5.3e-007-dxwnm       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.30909677+dvthnm    wvth0=-6.7186452e-009+dwvthnm
+ k1=0.4215                 k2=0.024548387+dk2m       wk2=-3.3593226e-009
+ k3=-2.2                   k3b=1.2                   w0=0
+ dvt0=0.2843               dvt1=0.1496               dvt2=-0.2039
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.684                minv=-0.112               voffl=-2.2e-009
+ dvtp0=0                   dvtp1=0                   lpe0=9.17e-008
+ lpeb=0                    web=0                     wec=0
+ scref=1e-006              kvth0we=0.0024949671      lkvth0we=0
+ wkvth0we=3.5118459e-011   pkvth0we=0                k2we=0.0043
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00037258065+dcitnm
+ wcit=-1.6796613e-010      voff=-0.11069032+dvoffnm  wvoff=-6.7186452e-010
+ nfactor=1.0654839         wnfactor=-3.3593226e-008  eta0=0.165+deta0nm
+ etab=-0.896               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.035273165+du0nm      wu0=8.945876e-010         ua=-3.1090929e-010
+ wua=-5.8297684e-017       ub=1.2657497e-018         wub=2.8258622e-025
+ uc=1.6994519e-010         wuc=-1.8029484e-017       vsat=88867.774+dvsatnm
+ wvsat=-0.00015788816      a0=0.90008387+da0nm       wa0=1.5385697e-007
+ ags=0.48979503            wags=3.5266168e-008       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.062121935         wketa=2.2171529e-009      dwg=0
+ dwb=0                     pclm=1.2119745+dpclmnm    wpclm=-1.5787808e-007
+ pdiblc1=0                 pdiblc2=0.00025114677+dpdiblc2nm
+ wpdiblc2=2.692497e-010    pdiblcb=0.5982258         wpdiblcb=-5.0389835e-008
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.21758613           wkt1=-3.3929158e-009
+ kt1l=0                    kt2=-0.038654002          wkt2=-2.0827766e-010
+ ute=-1.7122097            wute=3.1913565e-008       ua1=1.4649277e-009
+ wua1=4.5283668e-017       ub1=-2.8605583e-018       wub1=-1.2473168e-025
+ uc1=-1.5172261e-010       wuc1=1.2990501e-017       prt=0
+ at=189591.94              wat=-0.0011757629         jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 lvth0=0+dlvthnm
+ pvth0=0+dpvthnm           lk2=0+dlk2m               lcit=0+dlcitnm
+ pcit=0+dpcitnm            lvoff=0+dlvoffnm          pvoff=0+dpvoffnm
+ lu0=0+dlu0nm              pu0=0+dpu0nm              lvsat=0+dlvsatnm
+ pvsat=0+dpvsatnm          la0=0+dla0nm              pa0=0+dpa0nm
+ lpclm=0+dlpclmnm          ppclm=0+dppclmnm          lpdiblc2=0+dlpdiblc2nm
+ ppdiblc2=0+dppdiblc2nm    leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     14: type=n 
+ lmin=1.2e-006-dxlnm       lmax=1e-005-dxlnm         wmin=2.2e-07
+ wmax=5.3e-007-dxwnm       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.30781223+dvthnm    lvth0=1.2761154e-008+dlvthnm
+ wvth0=-6.5887287e-009+dwvthnm                       pvth0=-1.2906446e-015+dpvthnm
+ k1=0.4215                 k2=0.025331569+dk2m       lk2=-7.7804617e-009+dlk2m
+ wk2=-3.4251469e-009       pk2=6.5392662e-016        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025000001      lkvth0we=-5.0000015e-011  wkvth0we=3.2299973e-011
+ pkvth0we=2.8000019e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00038102226+dcitnm lcit=8.386255e-011+dlcitnm
+ wcit=-1.6363558e-010      pcit=-4.3021488e-017+dpcitnm
+ voff=-0.11029627+dvoffnm  lvoff=-3.914646e-009+dlvoffnm
+ wvoff=-6.4718039e-010     pvoff=-2.4522248e-016+dpvoffnm
+ nfactor=1.0952582         lnfactor=-2.9579106e-007  wnfactor=-4.2254323e-008
+ pnfactor=8.6042976e-014   eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.034874455+du0nm
+ lu0=3.9609439e-009+dlu0nm wu0=9.7552556e-010        pu0=-8.0407161e-016+dpu0nm
+ ua=-3.5309472e-010        lua=4.1908781e-016        wua=-4.5130651e-017
+ pua=-1.3080683e-022       ub=1.2851134e-018         lub=-1.9236706e-025
+ wub=2.7798284e-025        pub=4.5731842e-032        uc=1.6905703e-010
+ luc=8.8234144e-018        wuc=-1.777225e-017        puc=-2.5554764e-024
+ vsat=86755.844+dvsatnm    lvsat=0.020980799+dlvsatnm
+ wvsat=-0.00011934628      pvsat=-3.8289124e-010+dpvsatnm
+ a0=0.90037247+da0nm       la0=-2.8670251e-009+dla0nm
+ wa0=1.6693523e-007        pa0=-1.2992489e-013+dpa0nm
+ ags=0.48704082            lags=2.73615e-008         wags=2.9584489e-008
+ pags=5.6444192e-014       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.06128293
+ lketa=-8.3350286e-009     wketa=2.8580741e-009      pketa=-6.3671802e-015
+ dwg=0                     dwb=0                     pclm=1.2546345+dpclmnm
+ lpclm=-4.2380212e-007+dlpclmnm                      wpclm=-1.8243966e-007
+ ppclm=2.4400497e-013+dppclmnm                       pdiblc1=0
+ pdiblc2=6.2952692e-005+dpdiblc2nm                   lpdiblc2=1.8695991e-009+dlpdiblc2nm
+ wpdiblc2=2.4201489e-010   ppdiblc2=2.7056214e-016+dppdiblc2nm
+ pdiblcb=0.62462352        lpdiblcb=-2.6224604e-007  wpdiblcb=-5.7318713e-008
+ ppdiblcb=6.8834381e-014   drout=0.5                 pvag=1.787
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=78.59                 rdw=78.59                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=1e-008
+ bgidl=2.2849e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgonm                cgdo=cgonm                cgbo=0
+ cgdl=cglnm                cgsl=cglnm                clc=1e-007
+ cle=0.6                   cf=cfnm                   ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=1.586                voffcv=0.0135             kt1=-0.21106812
+ lkt1=-6.475263e-008       wkt1=-4.7527081e-009      pkt1=1.3508747e-014
+ kt1l=0                    kt2=-0.038275963          lkt2=-3.7555963e-009
+ wkt2=-5.0405413e-010      pkt2=2.9383676e-015       ute=-1.7778526
+ lute=6.5212428e-007       wute=3.6027586e-008       pute=-4.0870414e-014
+ ua1=9.8540142e-010        lua1=4.7638159e-015       wua1=1.3383473e-016
+ pua1=-8.7970339e-022      ub1=-2.246456e-018        lub1=-6.1007509e-024
+ wub1=-2.7805476e-025      pub1=1.5231759e-030       uc1=-1.4699507e-010
+ luc1=-4.6965463e-017      wuc1=1.3184077e-017       puc1=-1.9230618e-024
+ prt=0                     at=211971.29              lat=-0.22232594
+ wat=-0.0014100455         pat=2.3274621e-009        jss=2.34e-07
+ jsd=2.34e-07              jsws=7.68e-13             jswd=7.68e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.3
+ bvd=11.3                  xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjnm
+ cjd=cjnm                  mjs=0.333                 mjd=0.333
+ pbsws=0.29                pbswd=0.29                cjsws=cjswnm
+ cjswd=cjswnm              mjsws=0.146               mjswd=0.146
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgnm
+ cjswgd=cjswgnm            mjswgs=0.713              mjswgd=0.713
+ tpb=0.00149               tcj=0.000913              tpbsw=0.001
+ tcjsw=0.000765            tpbswg=0.00115            tcjswg=0.00083
+ xtis=3                    xtid=3                    jtsswgs=3.9893e-010
+ jtsswgd=3.9893e-010       njtsswg=17.974            xtsswgs=0.30393
+ xtsswgd=0.30393           tnjtsswg=0                vtsswgs=11.126
+ vtsswgd=11.126            dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-4e-008
+ lku0=2e-007               wku0=2e-006               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 leta0=0+dleta0nm
+ peta0=0+dpeta0nm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noian_m              noib=noibn_m
+ noic=noicn_m              em=4.10e7                 ef=0.98
+ minr=1e-3
 
 
 
     15: type=n 
+ lmin=5e-007-dxlnm         lmax=1.2e-006-dxlnm       wmin=2.2e-07
+ wmax=5.3e-007-dxwnm       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.3286886+dvthnm     lvth0=-1.092141e-008+dlvthnm
+ wvth0=-1.0436676e-008+dwvthnm                       pvth0=3.074544e-015+dpvthnm
+ k1=0.4215                 k2=0.017106451+dk2m       lk2=1.5502771e-009+dlk2m
+ wk2=-2.1794862e-009       pk2=-7.5917586e-016       k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0025000001      lkvth0we=-5.000007e-011   wkvth0we=3.2299978e-011
+ pkvth0we=2.8000014e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-3.4031613e-006+dcitnm
+ lcit=-3.4451611e-010+dlcitnm                        wcit=-3.8919096e-010
+ pcit=2.1285304e-016+dpcitnm                         voff=-0.10975879+dvoffnm
+ lvoff=-4.5243799e-009+dlvoffnm                      wvoff=-1.9828811e-009
+ pvoff=1.2700232e-015+dpvoffnm                       nfactor=0.89657613
+ lnfactor=-7.0402105e-008  wnfactor=3.3593226e-008   pnfactor=4.9679238e-029
+ eta0=0.165+deta0nm        etab=-0.896               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.044453872+du0nm      lu0=-6.9061377e-009+dlu0nm
+ wu0=-8.6906643e-010       pu0=1.2884704e-015+dpu0nm ua=6.0180554e-010
+ lua=-6.6417014e-016       wua=-2.4395063e-016       pua=9.4738525e-023
+ ub=6.5727347e-019         lub=5.1986709e-025        wub=4.230151e-025
+ pub=-1.1879565e-031       uc=2.133548e-010          luc=-4.1428868e-017
+ wuc=-2.7438455e-017       puc=8.4100603e-024        vsat=122993.5+dvsatnm
+ lvsat=-0.020127926+dlvsatnm                         wvsat=-0.0044530041
+ pvsat=4.5332968e-009+dpvsatnm                       a0=0.98080136+da0nm
+ la0=-9.4107175e-008+dla0nm                          wa0=1.0535924e-007
+ pa0=-6.0071859e-014+dpa0nm                          ags=0.6041304
+ lags=-1.0546726e-007      wags=1.0178956e-007       pags=-2.5466684e-014
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.073867786         lketa=5.9414835e-009
+ wketa=-5.7984461e-009     pketa=3.4529494e-015      dwg=0
+ dwb=0                     pclm=1.029089+dpclmnm     lpclm=-1.6793882e-007+dlpclmnm
+ wpclm=-3.828047e-008      ppclm=8.0467911e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=-0.0013310708+dpdiblc2nm
+ lpdiblc2=3.4510072e-009+dlpdiblc2nm                 wpdiblc2=1.010139e-009
+ ppdiblc2=-6.0081319e-016+dppdiblc2nm                pdiblcb=0.69968769
+ lpdiblcb=-3.4740033e-007  wpdiblcb=5.4441205e-009   ppdiblcb=-2.3650326e-015
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.28837103           lkt1=2.2941332e-008
+ wkt1=1.1512582e-008       pkt1=-4.942923e-015       kt1l=0
+ kt2=-0.044255352          lkt2=3.027542e-009        wkt2=2.0798857e-009
+ pkt2=7.0946284e-018       ute=-1.1398089            lute=-7.168524e-008
+ wute=-3.1271934e-009      pute=3.5475507e-015       ua1=5.7428456e-009
+ lua1=-6.3312391e-016      wua1=-7.3628035e-016      pua1=1.0737256e-022
+ ub1=-8.4882791e-018       lub1=9.800981e-025        wub1=1.2101761e-024
+ pub1=-1.6510303e-031      uc1=-2.4885713e-010       luc1=6.8588905e-017
+ wuc1=1.986976e-017        puc1=-9.5074348e-024      prt=0
+ at=7294.1915              lat=0.0098638559          wat=0.0010398256
+ pat=-4.5172075e-010       jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
     16: type=n 
+ lmin=2.85e-07             lmax=5e-007-dxlnm         wmin=2.2e-07
+ wmax=5.3e-007-dxwnm       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxnm                toxm=toxnm
+ dtox=4.295e-010           epsrox=3.9                wint=8.5e-009
+ lint=2.529e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlnm
+ xw=0+dxwnm                dlc=dlcnm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.33044+dvthnm       lvth0=-1.1682253e-008+dlvthnm
+ wvth0=-1.2320368e-008+dwvthnm                       pvth0=3.8928574e-015+dpvthnm
+ k1=0.4215                 k2=0.0074423781+dk2m      lk2=5.7485436e-009+dlk2m
+ wk2=-6.129729e-009        pk2=9.5688862e-016        k3=-2.2
+ k3b=1.2                   w0=0                      dvt0=0.2843
+ dvt1=0.1496               dvt2=-0.2039              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.684
+ minv=-0.112               voffl=-2.2e-009           dvtp0=0
+ dvtp1=0                   lpe0=9.17e-008            lpeb=0
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0026160151      lkvth0we=-1.003993e-010   wkvth0we=-2.8019053e-011
+ pkvth0we=5.4203808e-017   k2we=0.0043               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.0029051815+dcitnm  lcit=9.1607446e-010+dlcitnm
+ wcit=1.0444424e-009       pcit=-4.0994598e-016+dpcitnm
+ voff=-0.16858891+dvoffnm  lvoff=2.1032602e-008+dlvoffnm
+ wvoff=1.8309704e-008      pvoff=-7.5454815e-015+dpvoffnm
+ nfactor=0.37399833        lnfactor=1.5661614e-007   wnfactor=8.0423164e-008
+ pnfactor=-2.0343862e-014  eta0=0.165+deta0nm        etab=-0.896
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.012314766+du0nm
+ lu0=7.0557326e-009+dlu0nm wu0=6.1182683e-009        pu0=-1.7469675e-015+dpu0nm
+ ua=-1.9311316e-009        lua=4.3618839e-016        wua=2.3312385e-016
+ pua=-1.1251217e-022       ub=1.5570098e-018         lub=1.2900364e-025
+ wub=1.4147203e-025        pub=3.5122889e-033        uc=-9.607384e-012
+ luc=5.5430365e-017        wuc=2.6537682e-017        puc=-1.5038253e-023
+ vsat=58952.332+dvsatnm    lvsat=0.0076928398+dlvsatnm
+ wvsat=0.01223157          pvsat=-2.7148158e-009+dpvsatnm
+ a0=-0.88631388+da0nm      la0=7.1700503e-007+dla0nm wa0=3.4375274e-007
+ pa0=-1.6363476e-013+dpa0nm                          ags=0.16371667
+ lags=8.5857274e-008       wags=4.4428488e-008       pags=-5.4788754e-016
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.026967797         lketa=-1.443281e-008
+ wketa=-1.0335762e-008     pketa=5.4240503e-015      dwg=0
+ dwb=0                     pclm=0.048062856+dpclmnm  lpclm=2.5823858e-007+dlpclmnm
+ wpclm=2.6204978e-007      ppclm=-5.0001558e-014+dppclmnm
+ pdiblc1=0                 pdiblc2=0.0050956954+dpdiblc2nm
+ lpdiblc2=6.5909141e-010+dlpdiblc2nm                 wpdiblc2=3.2671775e-010
+ ppdiblc2=-3.0392134e-016+dppdiblc2nm                pdiblcb=0.17696291
+ lpdiblcb=-1.2031824e-007  wpdiblcb=-7.3024789e-008  ppdiblcb=3.1723431e-014
+ drout=0.5                 pvag=1.787                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=78.59
+ rdw=78.59                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=1e-008              bgidl=2.2849e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgonm
+ cgdo=cgonm                cgbo=0                    cgdl=cglnm
+ cgsl=cglnm                clc=1e-007                cle=0.6
+ cf=cfnm                   ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=1.586
+ voffcv=0.0135             kt1=-0.25070184           lkt1=6.5770824e-009
+ wkt1=3.8267757e-009       pkt1=-1.6040551e-015      kt1l=0
+ kt2=-0.056119943          lkt2=8.1817576e-009       wkt2=8.2152962e-009
+ pkt2=-2.6582504e-015      ute=-0.5847423            lute=-3.1281728e-007
+ wute=-1.9240979e-007      pute=8.5775695e-014       ua1=7.6256844e-009
+ lua1=-1.4510668e-015      wua1=-1.2406931e-015      pua1=3.2649954e-022
+ ub1=-1.0148334e-017       lub1=1.7012591e-024       wub1=1.5857256e-024
+ pub1=-3.2824923e-031      uc1=-1.9000503e-010       luc1=4.3022373e-017
+ wuc1=1.0876475e-017       puc1=-5.6005716e-024      prt=0
+ at=57696.289              lat=-0.012031823          wat=-0.0073024788
+ pat=3.1723431e-009        jss=2.34e-07              jsd=2.34e-07
+ jsws=7.68e-13             jswd=7.68e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.3                  bvd=11.3
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjnm                  cjd=cjnm
+ mjs=0.333                 mjd=0.333                 pbsws=0.29
+ pbswd=0.29                cjsws=cjswnm              cjswd=cjswnm
+ mjsws=0.146               mjswd=0.146               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgnm            cjswgd=cjswgnm
+ mjswgs=0.713              mjswgd=0.713              tpb=0.00149
+ tcj=0.000913              tpbsw=0.001               tcjsw=0.000765
+ tpbswg=0.00115            tcjswg=0.00083            xtis=3
+ xtid=3                    jtsswgs=3.9893e-010       jtsswgd=3.9893e-010
+ njtsswg=17.974            xtsswgs=0.30393           xtsswgd=0.30393
+ tnjtsswg=0                vtsswgs=11.126            vtsswgd=11.126
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-4e-008               lku0=2e-007
+ wku0=2e-006               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 leta0=0+dleta0nm          peta0=0+dpeta0nm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noian_m              noib=noibn_m              noic=noicn_m
+ em=4.10e7                 ef=0.98                   minr=1e-3
 
 
 
// *********************************************************************************************
//                                                                            
//                   *
//                                1.8V MED-VT PMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
     } 
model mepch bsim4  { 
     1: type=p 
+ lmin=1e-005-dxlpm         lmax=2.001e-05            wmin=1.003e-005-dxwpm
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.152+dvthpm        k1=0.1926                 k2=0.046064+dk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022480615     lkvth0we=0
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00080985+dcitpm
+ voff=-0.096782+dvoffpm    nfactor=0.7107            eta0=0.21+deta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.016493               ua=2.751e-009+duapm       ub=2.014e-019
+ uc=4.958e-011             vsat=152900               a0=1.656
+ ags=0.74044+dagspm        a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.043
+ dwg=0                     dwb=0                     pclm=0.83966
+ pdiblc1=0                 pdiblc2=0.0029299+dpdiblc2pm
+ pdiblcb=2.5737481e-010    drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.3138
+ kt1l=0                    kt2=-0.018                ute=-1.552
+ ua1=1.804e-009            ub1=-8.267e-018           uc1=-2.971e-010
+ prt=0                     at=283100                 jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  lvth0=0+dlvthpm
+ wvth0=0+dwvthpm           pvth0=0+dpvthpm           lk2=0+dlk2pm
+ wk2=0+dwk2pm              pk2=0+dpk2pm              lcit=0+dlcitpm
+ wcit=0+dwcitpm            pcit=0+dpcitpm            lvoff=0+dlvoffpm
+ wvoff=0+dwvoffpm          pvoff=0+dpvoffpm          lnfactor=0+dlnfactorpm
+ lua=0+dluapm              wua=0+dwuapm              pua=0+dpuapm
+ lpclm=0+dlpclmpm          wpclm=0+dwpclmpm          ppclm=0+dppclmpm
+ lpdiblc2=0+dlpdiblc2pm    wpdiblc2=0+dwpdiblc2pm    ppdiblc2=0+dppdiblc2pm
+ leta0=0+dleta0pm          weta0=0+dweta0pm          peta0=0+dpeta0pm
+ lvsat=0+dlvsatpm          wvsat=0+dwvsatpm          pvsat=0+dpvsatpm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noiap_m              noib=noibp_m              noic=noicp_m
+ em=2.10e7                 ef=1.12                   minr=1e-3
 
 
 
     2: type=p 
+ lmin=1.2e-006-dxlpm       lmax=1e-005-dxlpm         wmin=1.003e-005-dxwpm
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15091651+dvthpm   lvth0=-1.0800782e-008+dlvthpm
+ k1=0.1926                 k2=0.045203313+dk2pm      lk2=8.5797392e-009+dlk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022538798     lkvth0we=5.800007e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.000901866+dcitpm
+ lcit=9.172591e-010+dlcitpm                          voff=-0.094412122+dvoffpm
+ lvoff=-2.3624064e-008+dlvoffpm                      nfactor=0.70096714
+ lnfactor=9.7021735e-008+dlnfactorpm                 eta0=0.21+deta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.016470826            lu0=2.2104543e-010        ua=2.8349841e-009+duapm
+ lua=-8.3719301e-016+dluapm                          ub=3.8743108e-020
+ lub=1.621441e-024         uc=4.8950617e-011         luc=6.2739839e-018
+ vsat=152900               a0=1.7077846              la0=-5.1621387e-007
+ ags=0.72307754+dagspm     lags=1.7307724e-007       a1=0
+ a2=0.5705                 b0=0                      b1=0
+ keta=-0.041034839         lketa=-1.9589655e-008     dwg=0
+ dwb=0                     pclm=0.7829837            lpclm=5.6497623e-007+dlpclmpm
+ pdiblc1=0                 pdiblc2=0.0029537475+dpdiblc2pm
+ lpdiblc2=-2.377231e-010+dlpdiblc2pm                 pdiblcb=0.039834341
+ lpdiblcb=-3.9708759e-007  drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.30755929
+ lkt1=-6.2210389e-008      kt1l=0                    kt2=-0.016164965
+ lkt2=-1.8292503e-008      ute=-1.6069714            lute=5.4798088e-007
+ ua1=1.2800456e-009        lua1=5.2230255e-015       ub1=-7.6836925e-018
+ lub1=-5.814686e-024       uc1=-3.0506687e-010       luc1=7.9417518e-017
+ prt=0                     at=290097.57              lat=-0.069755054
+ jss=1.48e-07              jsd=1.48e-07              jsws=4.06e-13
+ jswd=4.06e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.1                  bvd=11.1                  xjbvs=1
+ xjbvd=1                   pbs=0.886                 pbd=0.886
+ cjs=cjpm                  cjd=cjpm                  mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswpm              cjswd=cjswpm              mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgpm            cjswgd=cjswgpm            mjswgs=0.70189
+ mjswgd=0.70189            tpb=0.00161               tcj=9.18e-04
+ tpbsw=0.00125             tcjsw=8.86e-04            tpbswg=0.00115
+ tcjswg=0.00158            xtis=3                    xtid=3
+ jtsswgs=5.4876e-010       jtsswgd=5.4876e-010       dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ rshg=8.41                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wlod=5e-006
+ kvth0=-2.3e-009           lkvth0=5e-008             wkvth0=2.5e-007
+ pkvth0=4e-014             llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=4.8e-008              lku0=2.5e-007             wku0=1e-008
+ pku0=-1e-012              llodku0=1                 wlodku0=1
+ kvsat=-0.6                steta0=0                  tku0=0.5
+ wvth0=0+dwvthpm           pvth0=0+dpvthpm           wk2=0+dwk2pm
+ pk2=0+dpk2pm              wcit=0+dwcitpm            pcit=0+dpcitpm
+ wvoff=0+dwvoffpm          pvoff=0+dpvoffpm          wua=0+dwuapm
+ pua=0+dpuapm              wpclm=0+dwpclmpm          ppclm=0+dppclmpm
+ wpdiblc2=0+dwpdiblc2pm    ppdiblc2=0+dppdiblc2pm    leta0=0+dleta0pm
+ weta0=0+dweta0pm          peta0=0+dpeta0pm          lvsat=0+dlvsatpm
+ wvsat=0+dwvsatpm          pvsat=0+dpvsatpm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     3: type=p 
+ lmin=5e-007-dxlpm         lmax=1.2e-006-dxlpm       wmin=1.003e-005-dxwpm
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.16430934+dvthpm   lvth0=4.8483972e-009+dlvthpm
+ k1=0.1926                 k2=0.053645575+dk2pm      lk2=-1.2848253e-009+dlk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022538798     lkvth0we=5.7999969e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-5.5864685e-005+dcitpm
+ lcit=-7.1271439e-011+dlcitpm                        voff=-0.11210024+dvoffpm
+ lvoff=-2.9559583e-009+dlvoffpm                      nfactor=0.78667699
+ lnfactor=-3.1279982e-009+dlnfactorpm                eta0=0.21+deta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.01666                ua=2.097084e-009+duapm    lua=2.5023986e-017+dluapm
+ ub=1.3802888e-018         lub=5.3879769e-026        uc=4.7694439e-011
+ luc=7.7417956e-018        vsat=162108.86            lvsat=-0.010760314+dlvsatpm
+ a0=1.266                  ags=0.72677616+dagspm     lags=1.687555e-007
+ a1=0                      a2=0.5705                 b0=0
+ b1=0                      keta=-0.055658405         lketa=-2.5023986e-009
+ dwg=0                     dwb=0                     pclm=1.0110478
+ lpclm=2.9848923e-007+dlpclmpm                       pdiblc1=0
+ pdiblc2=0.0031907325+dpdiblc2pm                     lpdiblc2=-5.1463391e-010+dlpdiblc2pm
+ pdiblcb=-0.26653757       lpdiblcb=-3.9099978e-008  drout=0.5
+ pvag=0.895                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0.017
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=200                  rsw=140                   rdw=140
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=2.593e-009          bgidl=2.5204e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgopm                cgdo=cgopm
+ cgbo=0                    cgdl=cglpm                cgsl=cglpm
+ clc=1e-007                cle=0.6                   cf=cfpm
+ ckappas=0.6               ckappad=0.6               acde=0.3322
+ moin=9.77                 noff=1.919                voffcv=-0.0543
+ kt1=-0.34025407           lkt1=-2.4007386e-008      kt1l=0
+ kt2=-0.053115491          lkt2=2.4883227e-008       ute=-1.0770984
+ lute=-7.116196e-008       ua1=6.4573957e-009        lua1=-8.2657353e-016
+ ub1=-1.3677258e-017       lub1=1.1886393e-024       uc1=-7.1862528e-011
+ luc1=-1.9307569e-016      prt=0                     at=219758.95
+ lat=0.012433793           jss=1.48e-07              jsd=1.48e-07
+ jsws=4.06e-13             jswd=4.06e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.1                  bvd=11.1
+ xjbvs=1                   xjbvd=1                   pbs=0.886
+ pbd=0.886                 cjs=cjpm                  cjd=cjpm
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswpm              cjswd=cjswpm
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgpm            cjswgd=cjswgpm
+ mjswgs=0.70189            mjswgd=0.70189            tpb=0.00161
+ tcj=9.18e-04              tpbsw=0.00125             tcjsw=8.86e-04
+ tpbswg=0.00115            tcjswg=0.00158            xtis=3
+ xtid=3                    jtsswgs=5.4876e-010       jtsswgd=5.4876e-010
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             rshg=8.41                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=5e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=4.8e-008              lku0=2.5e-007
+ wku0=1e-008               pku0=-1e-012              llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  wvth0=0+dwvthpm           pvth0=0+dpvthpm
+ wk2=0+dwk2pm              pk2=0+dpk2pm              wcit=0+dwcitpm
+ pcit=0+dpcitpm            wvoff=0+dwvoffpm          pvoff=0+dpvoffpm
+ wua=0+dwuapm              pua=0+dpuapm              wpclm=0+dwpclmpm
+ ppclm=0+dppclmpm          wpdiblc2=0+dwpdiblc2pm    ppdiblc2=0+dppdiblc2pm
+ leta0=0+dleta0pm          weta0=0+dweta0pm          peta0=0+dpeta0pm
+ wvsat=0+dwvsatpm          pvsat=0+dpvsatpm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     4: type=p 
+ lmin=2.5e-07              lmax=5e-007-dxlpm         wmin=1.003e-005-dxwpm
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15226464+dvthpm   lvth0=-7.9423126e-010+dlvthpm
+ k1=0.1926                 k2=0.048013026+dk2pm      lk2=1.3538777e-009+dlk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022538798     lkvth0we=5.8000007e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5.230624e-006+dcitpm
+ lcit=-9.9893003e-011+dlcitpm                        voff=-0.1115237+dvoffpm
+ lvoff=-3.2260527e-009+dlvoffpm                      nfactor=0.58774288
+ lnfactor=9.0067462e-008+dlnfactorpm                 eta0=0.31967307+deta0pm
+ leta0=-5.1378984e-008+dleta0pm                      etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.017242015
+ lu0=-2.7265877e-010       ua=2.8309154e-009+duapm   lua=-3.1875694e-016+dluapm
+ ub=1.127652e-018          lub=1.7223355e-025        uc=8.3052459e-011
+ luc=-8.8225173e-018       vsat=166781.33            lvsat=-0.012949245+dlvsatpm
+ a0=1.6068194              la0=-1.5966505e-007       ags=1.3622772+dagspm
+ lags=-1.2896023e-007      a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.062398234
+ lketa=6.5503609e-010      dwg=0                     dwb=0
+ pclm=2.1834613            lpclm=-2.50756e-007+dlpclmpm
+ pdiblc1=0                 pdiblc2=0.002594865+dpdiblc2pm
+ lpdiblc2=-2.3548547e-010+dlpdiblc2pm                pdiblcb=-0.5247792
+ lpdiblcb=8.1879511e-008   drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.384771
+ lkt1=-3.1523612e-009      kt1l=0                    kt2=0.035654956
+ lkt2=-1.670342e-008       ute=-1.3705712            lute=6.6322404e-008
+ ua1=4.9857552e-009        lua1=-1.3714818e-016      ub1=-1.2959452e-017
+ lub1=8.5236591e-025       uc1=-7.9501959e-010       luc1=1.4570459e-016
+ prt=0                     at=439203.8               lat=-0.090370417
+ jss=1.48e-07              jsd=1.48e-07              jsws=4.06e-13
+ jswd=4.06e-13             jswgs=1e-12               jswgd=1e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.1                  bvd=11.1                  xjbvs=1
+ xjbvd=1                   pbs=0.886                 pbd=0.886
+ cjs=cjpm                  cjd=cjpm                  mjs=0.44
+ mjd=0.44                  pbsws=0.6                 pbswd=0.6
+ cjsws=cjswpm              cjswd=cjswpm              mjsws=0.338
+ mjswd=0.338               pbswgs=0.95               pbswgd=0.95
+ cjswgs=cjswgpm            cjswgd=cjswgpm            mjswgs=0.70189
+ mjswgd=0.70189            tpb=0.00161               tcj=9.18e-04
+ tpbsw=0.00125             tcjsw=8.86e-04            tpbswg=0.00115
+ tcjswg=0.00158            xtis=3                    xtid=3
+ jtsswgs=5.4876e-010       jtsswgd=5.4876e-010       dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ rshg=8.41                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wlod=5e-006
+ kvth0=-2.3e-009           lkvth0=5e-008             wkvth0=2.5e-007
+ pkvth0=4e-014             llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=4.8e-008              lku0=2.5e-007             wku0=1e-008
+ pku0=-1e-012              llodku0=1                 wlodku0=1
+ kvsat=-0.6                steta0=0                  tku0=0.5
+ wvth0=0+dwvthpm           pvth0=0+dpvthpm           wk2=0+dwk2pm
+ pk2=0+dpk2pm              wcit=0+dwcitpm            pcit=0+dpcitpm
+ wvoff=0+dwvoffpm          pvoff=0+dpvoffpm          wua=0+dwuapm
+ pua=0+dpuapm              wpclm=0+dwpclmpm          ppclm=0+dppclmpm
+ wpdiblc2=0+dwpdiblc2pm    ppdiblc2=0+dppdiblc2pm    weta0=0+dweta0pm
+ peta0=0+dpeta0pm          wvsat=0+dwvsatpm          pvsat=0+dpvsatpm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noiap_m              noib=noibp_m              noic=noicp_m
+ em=2.10e7                 ef=1.12                   minr=1e-3
 
 
 
     5: type=p 
+ lmin=1e-005-dxlpm         lmax=2.001e-05            wmin=1.23e-006-dxwpm
+ wmax=1.003e-005-dxwpm     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15120896+dvthpm   wvth0=-7.9514975e-009+dwvthpm
+ k1=0.1926                 k2=0.045888151+dk2pm      wk2=1.7676351e-009+dwk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022441817     lkvth0we=0
+ wkvth0we=-3.899995e-011   pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00092506957+dcitpm
+ wcit=1.1581871e-009+dwcitpm                         voff=-0.094680916+dvoffpm
+ wvoff=-2.1120093e-008+dwvoffpm                      nfactor=0.73498595
+ wnfactor=-2.4412242e-007  eta0=0.21+deta0pm         etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.01646924
+ wu0=2.3883095e-010        ua=2.744114e-009+duapm    wua=6.9218072e-017+dwuapm
+ ub=2.5870745e-019         wub=-5.7605453e-025       uc=5.4432923e-011
+ wuc=-4.8781579e-017       vsat=152900               a0=1.6483173
+ wa0=7.7226775e-008        ags=0.75216896+dagspm     wags=-1.1789954e-007
+ a1=0                      a2=0.5705                 b0=0
+ b1=0                      keta=-0.042743909         wketa=-2.5742258e-009
+ dwg=0                     dwb=0                     pclm=0.74135808
+ wpclm=9.8813088e-007+dwpclmpm                       pdiblc1=0
+ pdiblc2=0.0029927703+dpdiblc2pm                     wpdiblc2=-6.3197244e-010+dwpdiblc2pm
+ pdiblcb=-5.2018262e-011   wpdiblcb=3.1100192e-015   drout=0.5
+ pvag=0.895                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0.017
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=200                  rsw=140                   rdw=140
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=2.593e-009          bgidl=2.5204e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgopm                cgdo=cgopm
+ cgbo=0                    cgdl=cglpm                cgsl=cglpm
+ clc=1e-007                cle=0.6                   cf=cfpm
+ ckappas=0.6               ckappad=0.6               acde=0.3322
+ moin=9.77                 noff=1.919                voffcv=-0.0543
+ kt1=-0.31324514           wkt1=-5.5774893e-009      kt1l=0
+ kt2=-0.018967455          wkt2=9.7248531e-009       ute=-1.5713491
+ wute=1.9449706e-007       ua1=1.586465e-009         wua1=2.1866618e-015
+ ub1=-7.9934095e-018       wub1=-2.7501312e-024      uc1=-2.9002905e-010
+ wuc1=-7.1077235e-017      prt=0                     at=285262.55
+ wat=-0.021737907          jss=1.48e-07              jsd=1.48e-07
+ jsws=4.06e-13             jswd=4.06e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.1                  bvd=11.1
+ xjbvs=1                   xjbvd=1                   pbs=0.886
+ pbd=0.886                 cjs=cjpm                  cjd=cjpm
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswpm              cjswd=cjswpm
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgpm            cjswgd=cjswgpm
+ mjswgs=0.70189            mjswgd=0.70189            tpb=0.00161
+ tcj=9.18e-04              tpbsw=0.00125             tcjsw=8.86e-04
+ tpbswg=0.00115            tcjswg=0.00158            xtis=3
+ xtid=3                    jtsswgs=5.4876e-010       jtsswgd=5.4876e-010
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             rshg=8.41                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=5e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=4.8e-008              lku0=2.5e-007
+ wku0=1e-008               pku0=-1e-012              llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lvth0=0+dlvthpm           pvth0=0+dpvthpm
+ lk2=0+dlk2pm              pk2=0+dpk2pm              lcit=0+dlcitpm
+ pcit=0+dpcitpm            lvoff=0+dlvoffpm          pvoff=0+dpvoffpm
+ lnfactor=0+dlnfactorpm    lua=0+dluapm              pua=0+dpuapm
+ lpclm=0+dlpclmpm          ppclm=0+dppclmpm          lpdiblc2=0+dlpdiblc2pm
+ ppdiblc2=0+dppdiblc2pm    leta0=0+dleta0pm          weta0=0+dweta0pm
+ peta0=0+dpeta0pm          lvsat=0+dlvsatpm          wvsat=0+dwvsatpm
+ pvsat=0+dpvsatpm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noiap_m              noib=noibp_m
+ noic=noicp_m              em=2.10e7                 ef=1.12
+ minr=1e-3
 
 
 
     6: type=p 
+ lmin=1.2e-006-dxlpm       lmax=1e-005-dxlpm         wmin=1.23e-006-dxwpm
+ wmax=1.003e-005-dxwpm     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15009298+dvthpm   lvth0=-1.1124686e-008+dlvthpm
+ wvth0=-8.2781147e-009+dwvthpm                       pvth0=3.2558744e-015+dpvthpm
+ k1=0.1926                 k2=0.045040083+dk2pm      lk2=8.4539443e-009+dlk2pm
+ wk2=1.6407861e-009+dwk2pm pk2=1.2644908e-015+dpk2pm k3=0.1
+ k3b=0.1                   w0=0                      dvt0=9.8
+ dvt1=1.38                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.3                 voffl=0                   dvtp0=4.617e-006
+ dvtp1=1.1                 lpe0=6.841e-008           lpeb=1.217e-007
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=-0.00225          lkvth0we=5.8000088e-011   wkvth0we=-3.8999931e-011
+ pkvth0we=-1.8929502e-022  k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=7.65e+019           ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.0010415116+dcitpm  lcit=1.1607495e-009+dlcitpm
+ wcit=1.4037177e-009+dwcitpm                         pcit=-2.4475657e-015+dpcitpm
+ voff=-0.09198426+dvoffpm  lvoff=-2.6881551e-008+dlvoffpm
+ wvoff=-2.4404874e-008+dwvoffpm                      pvoff=3.2744253e-014+dpvoffpm
+ nfactor=0.72859116        lnfactor=6.3746336e-008+dlnfactorpm
+ wnfactor=-2.7767663e-007  pnfactor=3.3448431e-013   eta0=0.21+deta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.016443911            lu0=2.5249416e-010        wu0=2.705432e-010
+ pu0=-3.1612269e-016       ua=2.8345475e-009+duapm   lua=-9.0148401e-016+dluapm
+ wua=4.3883686e-018+dwuapm pua=6.4625321e-022+dpuapm ub=8.6453488e-020
+ lub=1.7171092e-024        wub=-4.7958474e-025       pub=-9.6165658e-031
+ uc=5.4358373e-011         luc=7.4314943e-019        wuc=-5.4358757e-017
+ puc=5.5595949e-023        vsat=152900               a0=1.6990818
+ la0=-5.0604482e-007       wa0=8.7481033e-008        pa0=-1.0221931e-013
+ ags=0.73465311+dagspm     lags=1.7460637e-007       wags=-1.1635761e-007
+ pags=-1.5370756e-014      a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.040650289
+ lketa=-2.0870202e-008     wketa=-3.8655029e-009     pketa=1.2872062e-014
+ dwg=0                     dwb=0                     pclm=0.6781787
+ lpclm=6.2980205e-007+dlpclmpm                       wpclm=1.0534999e-006+dwpclmpm
+ ppclm=-6.5162919e-013+dppclmpm                      pdiblc1=0
+ pdiblc2=0.0030641233+dpdiblc2pm                     lpdiblc2=-7.112808e-010+dlpdiblc2pm
+ wpdiblc2=-1.1094981e-009+dwpdiblc2pm                ppdiblc2=4.760202e-015+dppdiblc2pm
+ pdiblcb=0.039834341       lpdiblcb=-3.9708759e-007  wpdiblcb=3.522971e-015
+ ppdiblcb=-4.1164997e-021  drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.30674939
+ lkt1=-6.4752652e-008      wkt1=-8.141054e-009       pkt1=2.5554828e-014
+ kt1l=0                    kt2=-0.01724161           lkt2=-1.7204038e-008
+ wkt2=1.0822438e-008       pkt2=-1.0941251e-014      ute=-1.6333102
+ lute=6.1765772e-007       wute=2.6475772e-007       pute=-7.0039159e-013
+ ua1=9.890808e-010         lua1=5.9550089e-015       wua1=2.9247786e-015
+ pua1=-7.3578976e-021      ub1=-7.3358032e-018       lub1=-6.5553319e-024
+ wub1=-3.4969831e-024      pub1=7.4449733e-030       uc1=-2.9802992e-010
+ luc1=7.9756487e-017       wuc1=-7.0735426e-017      puc1=-3.4073104e-024
+ prt=0                     at=292654.94              lat=-0.073690853
+ wat=-0.025706685          pat=3.956266e-008         jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  leta0=0+dleta0pm
+ weta0=0+dweta0pm          peta0=0+dpeta0pm          lvsat=0+dlvsatpm
+ wvsat=0+dwvsatpm          pvsat=0+dpvsatpm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     7: type=p 
+ lmin=5e-007-dxlpm         lmax=1.2e-006-dxlpm       wmin=1.23e-006-dxwpm
+ wmax=1.003e-005-dxwpm     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.16347737+dvthpm   lvth0=4.5146256e-009+dlvthpm
+ wvth0=-8.36301e-009+dwvthpm                         pvth0=3.3550724e-015+dpvthpm
+ k1=0.1926                 k2=0.053396873+dk2pm      lk2=-1.3107482e-009+dlk2pm
+ wk2=2.4999524e-009+dwk2pm pk2=2.6057729e-016+dpk2pm k3=0.1
+ k3b=0.1                   w0=0                      dvt0=9.8
+ dvt1=1.38                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.3                 voffl=0                   dvtp0=4.617e-006
+ dvtp1=1.1                 lpe0=6.841e-008           lpeb=1.217e-007
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=-0.0022499999     lkvth0we=5.7999957e-011   wkvth0we=-3.9000189e-011
+ pkvth0we=1.1183575e-022   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=7.65e+019           ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=5.9637258e-005+dcitpm lcit=-1.2591431e-010+dlcitpm
+ wcit=-1.1610255e-009+dwcitpm                        pcit=5.4927009e-016+dpcitpm
+ voff=-0.11260873+dvoffpm  lvoff=-2.7823971e-009+dlvoffpm
+ wvoff=5.1113081e-009+dwvoffpm                       pvoff=-1.7446377e-015+dpvoffpm
+ nfactor=0.78620422        lnfactor=-3.5730271e-009+dlnfactorpm
+ wnfactor=4.7523151e-009   pnfactor=4.4734299e-015   eta0=0.21+deta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.01666                ua=2.0178984e-009+duapm   lua=5.2749282e-017+dluapm
+ wua=7.9597457e-016+dwuapm pua=-2.7869468e-022+dpuapm
+ ub=1.6100616e-018         lub=-6.3187292e-026       wub=-2.3096765e-024
+ pub=1.1767581e-030        uc=4.3699428e-011         luc=1.3197849e-017
+ wuc=4.0157851e-017        puc=-5.484425e-023        vsat=163220.98
+ lvsat=-0.012059798+dlvsatpm                         wvsat=-0.011179038+dwvsatpm
+ pvsat=1.3062415e-008+dpvsatpm                       a0=1.2876997
+ la0=-2.5355518e-008       wa0=-2.1812524e-007       pa0=2.5487367e-013
+ ags=0.74628359+dagspm     lags=1.6101645e-007       wags=-1.9608869e-007
+ pags=7.7792946e-014       a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.056845847
+ lketa=-1.9461125e-009     wketa=1.1936174e-008      pketa=-5.5917873e-015
+ dwg=0                     dwb=0                     pclm=0.90664904
+ lpclm=3.628404e-007+dlpclmpm                        wpclm=1.0494166e-006+dwpclmpm
+ ppclm=-6.4685796e-013+dppclmpm                      pdiblc1=0
+ pdiblc2=0.0027358956+dpdiblc2pm                     lpdiblc2=-3.2775517e-010+dlpdiblc2pm
+ wpdiblc2=4.5720207e-009+dwpdiblc2pm                 ppdiblc2=-1.878505e-015+dppdiblc2pm
+ pdiblcb=-0.26177678       lpdiblcb=-4.4662838e-008  wpdiblcb=-4.7855471e-008
+ ppdiblcb=5.5917873e-014   drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.34197219
+ lkt1=-2.3595735e-008      wkt1=1.7270509e-008       pkt1=-4.1379226e-015
+ kt1l=0                    kt2=-0.056290377          lkt2=2.8423431e-008
+ wkt2=3.1913952e-008       pkt2=-3.5586136e-014      ute=-1.0055298
+ lute=-1.1588736e-007      wute=-7.1940734e-007      pute=4.495797e-013
+ ua1=7.1229881e-009        lua1=-1.2123023e-015      wua1=-6.690534e-015
+ pua1=3.8773451e-021       ub1=-1.4281247e-017       lub1=1.5602384e-024
+ wub1=6.0712976e-024       pub1=-3.7353139e-030      uc1=-3.5266138e-011
+ luc1=-2.2727616e-016      wuc1=-3.6786691e-016      puc1=3.437831e-022
+ prt=0                     at=219062.25              lat=0.012300284
+ wat=0.0070031838          pat=1.342029e-009         jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  leta0=0+dleta0pm
+ weta0=0+dweta0pm          peta0=0+dpeta0pm          saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     8: type=p 
+ lmin=2.5e-07              lmax=5e-007-dxlpm         wmin=1.23e-006-dxwpm
+ wmax=1.003e-005-dxwpm     version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15411579+dvthpm   lvth0=1.2896953e-010+dlvthpm
+ wvth0=1.8607722e-008+dwvthpm                        pvth0=-9.2800143e-015+dpvthpm
+ k1=0.1926                 k2=0.04630628+dk2pm       lk2=2.0110103e-009+dlk2pm
+ wk2=1.7156206e-008+dwk2pm pk2=-6.6054966e-015+dpk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.00225          lkvth0we=5.8000007e-011
+ wkvth0we=-3.899995e-011   pkvth0we=-5.3891099e-031  k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5.5769611e-006+dcitpm
+ lcit=-1.0058846e-010+dlcitpm                        wcit=-3.4813805e-012+dwcitpm
+ pcit=6.990749e-018+dpcitpm                          voff=-0.11409487+dvoffpm
+ lvoff=-2.0861764e-009+dlvoffpm                      wvoff=2.5845434e-008+dwvoffpm
+ pvoff=-1.1458037e-014+dpvoffpm                      nfactor=0.53385223
+ lnfactor=1.1464732e-007+dlnfactorpm                 wnfactor=5.417088e-007
+ pnfactor=-2.4707672e-013  eta0=0.33476556+deta0pm   leta0=-5.844942e-008+dleta0pm
+ weta0=-1.5170966e-007+dweta0pm                      peta0=7.1072029e-014+dpeta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.017345086            lu0=-3.2094479e-010       wu0=-1.0360684e-009
+ pu0=4.853711e-016         ua=2.859252e-009+duapm    lua=-3.4140302e-016+dluapm
+ wua=-2.8483918e-016+dwuapm                          pua=2.2763846e-022+dpuapm
+ ub=1.1770235e-018         lub=1.396798e-025         wub=-4.9628281e-025
+ pub=3.2723028e-031        uc=9.8249569e-011         luc=-1.2357474e-017
+ wuc=-1.5276135e-016       puc=3.553338e-023         vsat=173352.82
+ lvsat=-0.016806302+dlvsatpm                         wvsat=-0.066056627+dwvsatpm
+ pvsat=3.8771139e-008+dpvsatpm                       a0=1.5662145
+ la0=-1.5583245e-007       wa0=4.0816118e-007        pa0=-3.8525233e-014
+ ags=1.4275675+dagspm      lags=-1.5814735e-007      wags=-6.5629785e-007
+ pags=2.9338897e-013       a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.062597164
+ lketa=7.4822986e-010      wketa=1.9996495e-009      pketa=-9.3678378e-016
+ dwg=0                     dwb=0                     pclm=2.2340424
+ lpclm=-2.5900889e-007+dlpclmpm                      wpclm=-5.0844153e-007+dwpclmpm
+ ppclm=8.2958059e-014+dppclmpm                       pdiblc1=0
+ pdiblc2=0.0025143324+dpdiblc2pm                     lpdiblc2=-2.2395857e-010+dlpdiblc2pm
+ wpdiblc2=8.0951396e-010+dwpdiblc2pm                 ppdiblc2=-1.1586844e-016+dppdiblc2pm
+ pdiblcb=-0.56297573       lpdiblcb=9.6441038e-008   wpdiblcb=3.839515e-007
+ ppdiblcb=-1.4637247e-013  drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.39047177
+ lkt1=-8.749384e-010       wkt1=5.7304174e-008       pkt1=-2.2892654e-014
+ kt1l=0                    kt2=0.043540619           lkt2=-1.8344795e-008
+ wkt2=-7.9266689e-008      pkt2=1.6499104e-014       ute=-1.4478112
+ lute=9.1309984e-008       wute=7.7641709e-007       pute=-2.5117515e-013
+ ua1=4.690091e-009         lua1=-7.2553249e-017      wua1=2.9720159e-015
+ pua1=-6.4930826e-022      ub1=-1.2604868e-017       lub1=7.7489864e-025
+ wub1=-3.5642743e-024      pub1=7.7870099e-031       uc1=-8.8548655e-010
+ luc1=1.7103e-016          wuc1=9.0937388e-016       puc1=-2.54571e-022
+ prt=0                     at=438157.47              lat=-0.090340128
+ wat=0.010517773           pat=-3.0446468e-010       jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     9: type=p 
+ lmin=1e-005-dxlpm         lmax=2.001e-05            wmin=5.3e-007-dxwpm
+ wmax=1.23e-006-dxwpm      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15595131+dvthpm   wvth0=-2.0140745e-009+dwvthpm
+ k1=0.1926                 k2=0.045959429+dk2pm      wk2=1.6783954e-009+dwk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022441817     lkvth0we=0
+ wkvth0we=-3.8999986e-011  pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00047314286+dcitpm
+ wcit=-5.9237486e-010+dwcitpm                        voff=-0.11737754+dvoffpm
+ wvoff=7.2960837e-009+dwvoffpm                       nfactor=0.17725714
+ wnfactor=4.5415406e-007   eta0=0.21+deta0pm         etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.01666
+ ua=2.8951326e-009+duapm   wua=-1.1985718e-016+dwuapm
+ ub=-1.2987657e-019        wub=-8.9547333e-026       uc=8.7040571e-012
+ wuc=8.4709605e-018        vsat=152900               a0=1.7525829
+ wa0=-5.3313737e-008       ags=0.65218034+dagspm     wags=7.2862107e-009
+ a1=0                      a2=0.5705                 b0=0
+ b1=0                      keta=-0.051266286         wketa=8.0957897e-009
+ dwg=0                     dwb=0                     pclm=2.2243063
+ wpclm=-8.6852027e-007+dwpclmpm                      pdiblc1=0
+ pdiblc2=0.0017530514+dpdiblc2pm                     wpdiblc2=9.2015561e-010+dwpdiblc2pm
+ pdiblcb=0.11828572        wpdiblcb=-1.4809372e-007  drout=0.5
+ pvag=0.895                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0.017
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=200                  rsw=140                   rdw=140
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=2.593e-009          bgidl=2.5204e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgopm                cgdo=cgopm
+ cgbo=0                    cgdl=cglpm                cgsl=cglpm
+ clc=1e-007                cle=0.6                   cf=cfpm
+ ckappas=0.6               ckappad=0.6               acde=0.3322
+ moin=9.77                 noff=1.919                voffcv=-0.0543
+ kt1=-0.30311143           wkt1=-1.8264891e-008      kt1l=0
+ kt2=-0.0086608            wkt2=-3.1790784e-009      ute=-1.3056
+ wute=-1.382208e-007       ua1=3.9528171e-009        wua1=-7.7601106e-016
+ ub1=-1.1152845e-017       wub1=1.2054825e-024       uc1=-3.8275886e-010
+ wuc1=4.5020489e-017       prt=0                     at=264509.14
+ wat=0.0042453531          jss=1.48e-07              jsd=1.48e-07
+ jsws=4.06e-13             jswd=4.06e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.1                  bvd=11.1
+ xjbvs=1                   xjbvd=1                   pbs=0.886
+ pbd=0.886                 cjs=cjpm                  cjd=cjpm
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswpm              cjswd=cjswpm
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgpm            cjswgd=cjswgpm
+ mjswgs=0.70189            mjswgd=0.70189            tpb=0.00161
+ tcj=9.18e-04              tpbsw=0.00125             tcjsw=8.86e-04
+ tpbswg=0.00115            tcjswg=0.00158            xtis=3
+ xtid=3                    jtsswgs=5.4876e-010       jtsswgd=5.4876e-010
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             rshg=8.41                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=5e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=4.8e-008              lku0=2.5e-007
+ wku0=1e-008               pku0=-1e-012              llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lvth0=0+dlvthpm           pvth0=0+dpvthpm
+ lk2=0+dlk2pm              pk2=0+dpk2pm              lcit=0+dlcitpm
+ pcit=0+dpcitpm            lvoff=0+dlvoffpm          pvoff=0+dpvoffpm
+ lnfactor=0+dlnfactorpm    lua=0+dluapm              pua=0+dpuapm
+ lpclm=0+dlpclmpm          ppclm=0+dppclmpm          lpdiblc2=0+dlpdiblc2pm
+ ppdiblc2=0+dppdiblc2pm    leta0=0+dleta0pm          weta0=0+dweta0pm
+ peta0=0+dpeta0pm          lvsat=0+dlvsatpm          wvsat=0+dwvsatpm
+ pvsat=0+dpvsatpm          saref=1.00e-05            sbref=1.00e-05
+ fnoimod=1                 noia=noiap_m              noib=noibp_m
+ noic=noicp_m              em=2.10e7                 ef=1.12
+ minr=1e-3
 
 
 
     10: type=p 
+ lmin=1.2e-006-dxlpm       lmax=1e-005-dxlpm         wmin=5.3e-007-dxwpm
+ wmax=1.23e-006-dxwpm      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.1543622+dvthpm    lvth0=-1.5840996e-008+dlvthpm
+ wvth0=-2.9330412e-009+dwvthpm                       pvth0=9.1606955e-015+dpvthpm
+ k1=0.1926                 k2=0.045681846+dk2pm      lk2=2.7670727e-009+dlk2pm
+ wk2=8.3729839e-010+dwk2pm pk2=8.3844539e-015+dpk2pm k3=0.1
+ k3b=0.1                   w0=0                      dvt0=9.8
+ dvt1=1.38                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.3                 voffl=0                   dvtp0=4.617e-006
+ dvtp1=1.1                 lpe0=6.841e-008           lpeb=1.217e-007
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=-0.00225          lkvth0we=5.7999937e-011   wkvth0we=-3.8999986e-011
+ pkvth0we=2.4069911e-030   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=7.65e+019           ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00065751895+dcitpm  lcit=-1.8379483e-009+dlcitpm
+ wcit=-7.2346853e-010+dwcitpm                        pcit=1.3068039e-015+dpcitpm
+ voff=-0.11751183+dvoffpm  lvoff=1.3386768e-009+dlvoffpm
+ wvoff=7.5556491e-009+dwvoffpm                       pvoff=-2.5874718e-015+dpvoffpm
+ nfactor=0.10217889        lnfactor=7.4841557e-007+dlnfactorpm
+ wnfactor=5.0659153e-007   pnfactor=-5.2272157e-013  eta0=0.20582217+deta0pm
+ leta0=4.1646547e-008+dleta0pm                       weta0=5.2306377e-009+dweta0pm
+ peta0=-5.2141476e-014+dpeta0pm                      etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.016625132
+ lu0=3.4757644e-010        wu0=4.3654195e-011        pu0=-4.351657e-016
+ ua=2.8990223e-009+duapm   lua=-3.8774658e-017+dluapm
+ wua=-7.6334078e-017+dwuapm                          pua=-4.338589e-022+dpuapm
+ ub=-1.9928541e-019        lub=6.9190024e-025        wub=-1.2183964e-025
+ pub=3.2190501e-031        uc=2.8744265e-012         luc=5.8112521e-017
+ wuc=1.0099144e-017        puc=-1.6230505e-023       vsat=152100.04
+ lvsat=0.0079744265+dlvsatpm                         wvsat=0.0010015557+dwvsatpm
+ pvsat=-9.9839819e-009+dpvsatpm                      a0=1.8587817
+ la0=-1.0586401e-006       wa0=-1.124632e-007        pa0=5.8962993e-013
+ ags=0.63064394+dagspm     lags=2.1468507e-007       wags=1.386187e-008
+ pags=-6.5549285e-014      a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.051230169
+ lketa=-3.6002608e-010     wketa=9.3805078e-009      pketa=-1.2806678e-014
+ dwg=0                     dwb=0                     pclm=2.5699406
+ lpclm=-3.4454466e-006+dlpclmpm                      wpclm=-1.314986e-006+dwpclmpm
+ ppclm=4.4505821e-012+dppclmpm                       pdiblc1=0
+ pdiblc2=0.0011608915+dpdiblc2pm                     lpdiblc2=5.9029309e-009+dlpdiblc2pm
+ wpdiblc2=1.2733482e-009+dwpdiblc2pm                 ppdiblc2=-3.5207911e-015+dppdiblc2pm
+ pdiblcb=0.17906154        lpdiblcb=-6.0584222e-007  wpdiblcb=-1.7431245e-007
+ ppdiblcb=2.6136079e-013   drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.30053752
+ lkt1=-2.5657909e-008      wkt1=-1.5918315e-008      pkt1=-2.339179e-014
+ kt1l=0                    kt2=-0.0060561956         lkt2=-2.5963931e-008
+ wkt2=-3.1817003e-009      pkt2=2.6136078e-017       ute=-1.306207
+ lute=6.0508585e-009       wute=-1.4477548e-007      pute=6.5340196e-014
+ ua1=4.0220477e-009        lua1=-6.9012311e-016      wua1=-8.7249601e-016
+ pua1=9.6180768e-022       ub1=-1.1156789e-017       lub1=3.931514e-026
+ wub1=1.2868917e-024       pub1=-8.1152484e-031      uc1=-3.9053907e-010
+ luc1=7.7556879e-017       wuc1=4.5086036e-017       puc1=-6.5340196e-025
+ prt=0                     at=266270.96              lat=-0.017562617
+ wat=0.0073260546          pat=-3.0709892e-008       jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     11: type=p 
+ lmin=5e-007-dxlpm         lmax=1.2e-006-dxlpm       wmin=5.3e-007-dxwpm
+ wmax=1.23e-006-dxwpm      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.18208226+dvthpm   lvth0=1.6549166e-008+dlvthpm
+ wvth0=1.4930315e-008+dwvthpm                        pvth0=-1.1712172e-014+dpvthpm
+ k1=0.1926                 k2=0.046197574+dk2pm      lk2=2.1644586e-009+dlk2pm
+ wk2=1.1513476e-008+dwk2pm pk2=-4.0903816e-015+dpk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022500001     lkvth0we=5.8000047e-011
+ wkvth0we=-3.8999986e-011  pkvth0we=2.5850801e-031   k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0016053282+dcitpm
+ lcit=8.0612983e-010+dlcitpm                         wcit=9.2351127e-010+dwcitpm
+ pcit=-6.1764917e-016+dpcitpm                        voff=-0.11486117+dvoffpm
+ lvoff=-1.7585606e-009+dlvoffpm                      wvoff=7.9313607e-009+dwvoffpm
+ pvoff=-3.0264809e-015+dpvoffpm                      nfactor=0.82184826
+ lnfactor=-9.2499376e-008+dlnfactorpm                wnfactor=-3.9874021e-008
+ pnfactor=1.1580922e-013   eta0=0.26252124+deta0pm   leta0=-2.4604834e-008+dleta0pm
+ weta0=-6.5756589e-008+dweta0pm                      peta0=3.0805252e-014+dpeta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.017098335            lu0=-2.0534861e-010       wu0=-5.4879559e-010
+ pu0=2.5709647e-016        ua=3.3227829e-009+duapm   lua=-5.3392785e-016+dluapm
+ wua=-8.3774082e-016+dwuapm                          pua=4.5582508e-022+dpuapm
+ ub=-8.7253762e-019        lub=1.4785779e-024        wub=7.985377e-025
+ pub=-7.5353198e-031       uc=5.1232828e-011         luc=1.6069867e-018
+ wuc=3.0726035e-017        puc=-4.0332491e-023       vsat=165446.46
+ lvsat=-0.0076205186+dlvsatpm                        wvsat=-0.013965332+dwvsatpm
+ pvsat=7.5044374e-009+dpvsatpm                       a0=0.28987036
+ la0=7.7459201e-007        wa0=1.0311571e-006        pa0=-7.4666064e-013
+ ags=0.50889233+dagspm     lags=3.5694866e-007       wags=1.0112516e-007
+ pags=-1.6751417e-013      a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.042567295
+ lketa=-1.0482369e-008     wketa=-5.9405726e-009     pketa=5.0956056e-015
+ dwg=0                     dwb=0                     pclm=-1.884615
+ lpclm=1.7595858e-006+dlpclmpm                       wpclm=4.5440791e-006+dwpclmpm
+ ppclm=-2.3955832e-012+dppclmpm                      pdiblc1=0
+ pdiblc2=0.011944037+dpdiblc2pm                      lpdiblc2=-6.696894e-009+dlpdiblc2pm
+ wpdiblc2=-6.9565721e-009+dwpdiblc2pm                ppdiblc2=6.0956568e-015+dppdiblc2pm
+ pdiblcb=-0.28665354       lpdiblcb=-6.1666251e-008  wpdiblcb=-1.6709766e-008
+ ppdiblcb=7.7206146e-014   drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.27224193
+ lkt1=-5.872057e-008       wkt1=-7.0031766e-008      pkt1=3.9838371e-014
+ kt1l=0                    kt2=-0.028065471          lkt2=-2.46665e-010
+ wkt2=-3.4236299e-009      pkt2=3.0882458e-016       ute=-1.5445241
+ lute=2.8451825e-007       wute=-4.4586422e-008      pute=-5.1728118e-014
+ ua1=7.8837106e-010        lua1=3.088344e-015        wua1=1.2404065e-015
+ pua1=-1.507064e-021       ub1=-8.8068621e-018       lub1=-2.7065138e-024
+ wub1=-7.8263205e-025      pub1=1.6066598e-030       uc1=-3.4708003e-010
+ luc1=2.6776119e-017       wuc1=2.2524089e-017       puc1=2.5709647e-023
+ prt=0                     at=223752.81              lat=0.032118733
+ wat=0.0011306033          pat=-2.3470668e-008       jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     12: type=p 
+ lmin=2.5e-07              lmax=5e-007-dxlpm         wmin=5.3e-007-dxwpm
+ wmax=1.23e-006-dxwpm      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.11660731+dvthpm   lvth0=-1.4124145e-008+dlvthpm
+ wvth0=-2.8352893e-008+dwvthpm                       pvth0=8.5648856e-015+dpvthpm
+ k1=0.1926                 k2=0.063592353+dk2pm      lk2=-5.984543e-009+dlk2pm
+ wk2=-4.485956e-009+dwk2pm pk2=3.4049361e-015+dpk2pm k3=0.1
+ k3b=0.1                   w0=0                      dvt0=9.8
+ dvt1=1.38                 dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.3                 voffl=0                   dvtp0=4.617e-006
+ dvtp1=1.1                 lpe0=6.841e-008           lpeb=1.217e-007
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=-0.0022500001     lkvth0we=5.8000039e-011   wkvth0we=-3.89999e-011
+ pkvth0we=-4.0419469e-023  k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=7.65e+019           ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0010322043+dcitpm   lcit=-4.2948559e-010+dlcitpm
+ wcit=-1.2888188e-009+dwcitpm                        pcit=4.1876996e-016+dpcitpm
+ voff=-0.078686963+dvoffpm lvoff=-1.8705234e-008+dlvoffpm
+ wvoff=-1.8485269e-008+dwvoffpm                      pvoff=9.3490233e-015+dpvoffpm
+ nfactor=0.94013113        lnfactor=-1.4791183e-007+dlnfactorpm
+ wnfactor=3.3047614e-008   pnfactor=8.1647329e-014   eta0=0.21528697+deta0pm
+ leta0=-2.4768084e-009+dleta0pm                      weta0=-2.1224635e-009+dweta0pm
+ peta0=9.9431895e-016+dpeta0pm                       etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.016175747
+ lu0=2.2686005e-010        wu0=4.2794386e-010        pu0=-2.0048057e-016
+ ua=2.460655e-009+duapm    lua=-1.3004338e-016+dluapm
+ wua=2.1420421e-016+dwuapm pua=-3.6983815e-023+dpuapm
+ ub=1.452202e-018          lub=3.8949789e-025        wub=-8.4080627e-025
+ pub=1.4458044e-032        uc=3.4441232e-011         luc=9.4734126e-018
+ wuc=-7.2873313e-017       puc=8.2011104e-024        vsat=87093.256
+ lvsat=0.029085918+dlvsatpm                          wvsat=0.041940349+dwvsatpm
+ pvsat=-1.8685921e-008+dpvsatpm                      a0=2.7921815
+ la0=-3.9767568e-007       wa0=-1.1267495e-006       pa0=2.6426249e-013
+ ags=0.95400668+dagspm     lags=1.4842416e-007       wags=-6.3399679e-008
+ pags=-9.0438563e-014      a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.06618329
+ lketa=5.8111059e-010      wketa=6.4894792e-009      pketa=-7.2755045e-016
+ dwg=0                     dwb=0                     pclm=2.5668983
+ lpclm=-3.2583247e-007+dlpclmpm                      wpclm=-9.2517712e-007+dwpclmpm
+ ppclm=1.6662118e-013+dppclmpm                       pdiblc1=0
+ pdiblc2=-0.0054211036+dpdiblc2pm                    lpdiblc2=1.4382227e-009+dlpdiblc2pm
+ wpdiblc2=1.074468e-008+dwpdiblc2pm                  ppdiblc2=-2.1969194e-015+dppdiblc2pm
+ pdiblcb=-0.31946056       lpdiblcb=-4.6297015e-008  wpdiblcb=7.9070512e-008
+ ppdiblcb=3.2335576e-014   drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.32836473
+ lkt1=-3.2428497e-008      wkt1=-2.0453841e-008      pkt1=1.6612402e-014
+ kt1l=0                    kt2=-0.013669851          lkt2=-6.9906387e-009
+ wkt2=-7.6391797e-009      pkt2=2.2837e-015          ute=-0.20651937
+ lute=-3.423022e-007       wute=-7.7768029e-007      pute=2.917073e-013
+ ua1=1.1754734e-008        lua1=-2.049112e-015       wua1=-5.8729174e-015
+ pua1=1.8253433e-021       ub1=-2.1551128e-017       lub1=3.2638433e-024
+ wub1=7.6364425e-024       pub1=-2.3374577e-030      uc1=-1.6474062e-010
+ luc1=-5.8645155e-017      wuc1=6.9999815e-018       puc1=3.2982287e-023
+ prt=0                     at=516558.17              lat=-0.10505296
+ wat=-0.087639902          pat=1.8116005e-008        jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     13: type=p 
+ lmin=1e-005-dxlpm         lmax=2.001e-05            wmin=2.2e-07
+ wmax=5.3e-007-dxwpm       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15913161+dvthpm   wvth0=-2.5854968e-010+dwvthpm
+ k1=0.1926                 k2=0.055245161+dk2pm      wk2=-3.447329e-009+dwk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022441816     lkvth0we=0
+ wkvth0we=-3.9000021e-011  pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0006+dcitpm
+ voff=-0.10284852+dvoffpm  wvoff=-7.239391e-010+dwvoffpm
+ nfactor=1                 eta0=0.21+deta0pm         etab=-0.05096
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.01666
+ ua=2.5815123e-009+duapm   wua=5.3261234e-017+dwuapm ub=4.5310387e-019
+ wub=-4.1135254e-025       uc=5.0685613e-011         wuc=-1.4702858e-017
+ vsat=152900               a0=1.6055703              wa0=2.7837182e-008
+ ags=0.61445071+dagspm     wags=2.8112968e-008       a1=0
+ a2=0.5705                 b0=0                      b1=0
+ keta=-0.040347097         wketa=2.0683974e-009      dwg=0
+ dwb=0                     pclm=0.6509               pdiblc1=0
+ pdiblc2=0.0040607535+dpdiblc2pm                     wpdiblc2=-3.5369596e-010+dwpdiblc2pm
+ pdiblcb=-0.26709677       wpdiblcb=6.4637417e-008   drout=0.5
+ pvag=0.895                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0.017
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=200                  rsw=140                   rdw=140
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=2.593e-009          bgidl=2.5204e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgopm                cgdo=cgopm
+ cgbo=0                    cgdl=cglpm                cgsl=cglpm
+ clc=1e-007                cle=0.6                   cf=cfpm
+ ckappas=0.6               ckappad=0.6               acde=0.3322
+ moin=9.77                 noff=1.919                voffcv=-0.0543
+ kt1=-0.35072              wkt1=8.01504e-009         kt1l=0
+ kt2=-0.01162529           wkt2=-1.5426797e-009      ute=-1.6044
+ wute=2.67168e-008         ua1=2.8553548e-009        wua1=-1.7021187e-016
+ ub1=-1.0301562e-017       wub1=7.3557396e-025       uc1=-3.2532194e-010
+ wuc1=1.3315308e-017       prt=0                     at=338164.52
+ wat=-0.036412417          jss=1.48e-07              jsd=1.48e-07
+ jsws=4.06e-13             jswd=4.06e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.1                  bvd=11.1
+ xjbvs=1                   xjbvd=1                   pbs=0.886
+ pbd=0.886                 cjs=cjpm                  cjd=cjpm
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswpm              cjswd=cjswpm
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgpm            cjswgd=cjswgpm
+ mjswgs=0.70189            mjswgd=0.70189            tpb=0.00161
+ tcj=9.18e-04              tpbsw=0.00125             tcjsw=8.86e-04
+ tpbswg=0.00115            tcjswg=0.00158            xtis=3
+ xtid=3                    jtsswgs=5.4876e-010       jtsswgd=5.4876e-010
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             rshg=8.41                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=5e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=4.8e-008              lku0=2.5e-007
+ wku0=1e-008               pku0=-1e-012              llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lvth0=0+dlvthpm           pvth0=0+dpvthpm
+ lk2=0+dlk2pm              pk2=0+dpk2pm              lcit=0+dlcitpm
+ wcit=0+dwcitpm            pcit=0+dpcitpm            lvoff=0+dlvoffpm
+ pvoff=0+dpvoffpm          lnfactor=0+dlnfactorpm    lua=0+dluapm
+ pua=0+dpuapm              lpclm=0+dlpclmpm          wpclm=0+dwpclmpm
+ ppclm=0+dppclmpm          lpdiblc2=0+dlpdiblc2pm    ppdiblc2=0+dppdiblc2pm
+ leta0=0+dleta0pm          weta0=0+dweta0pm          peta0=0+dpeta0pm
+ lvsat=0+dlvsatpm          wvsat=0+dwvsatpm          pvsat=0+dpvsatpm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noiap_m              noib=noibp_m              noic=noicp_m
+ em=2.10e7                 ef=1.12                   minr=1e-3
 
 
 
     14: type=p 
+ lmin=1.2e-006-dxlpm       lmax=1e-005-dxlpm         wmin=2.2e-07
+ wmax=5.3e-007-dxwpm       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.15991941+dvthpm   lvth0=7.8531116e-009+dlvthpm
+ wvth0=1.3453478e-010+dwvthpm                        pvth0=-3.9184522e-015+dpvthpm
+ k1=0.1926                 k2=0.05288764+dk2pm       lk2=2.350089e-008+dlk2pm
+ wk2=-3.1402997e-009+dwk2pm                          pk2=-3.0606134e-015+dpk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022499999     lkvth0we=5.7999834e-011
+ wkvth0we=-3.9000027e-011  pkvth0we=5.703715e-023    k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00069457444+dcitpm
+ lcit=9.427628e-010+dlcitpm                          wcit=2.2887013e-011+dwcitpm
+ pcit=-2.281486e-016+dpcitpm                         voff=-0.10282458+dvoffpm
+ lvoff=-2.3859414e-010+dlvoffpm                      wvoff=-5.5171432e-010+dwvoffpm
+ pvoff=-1.7168182e-015+dpvoffpm                      nfactor=1.0354654
+ lnfactor=-3.5353605e-007+dlnfactorpm                wnfactor=-8.58263e-009
+ pnfactor=8.5555724e-014   eta0=0.2194338+deta0pm    leta0=-9.4040589e-008+dleta0pm
+ weta0=-2.2829796e-009+dweta0pm                      peta0=2.2757823e-014+dpeta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.016738733            lu0=-7.8485003e-010       wu0=-1.9053439e-011
+ pu0=1.8993371e-016        ua=2.6216564e-009+duapm   lua=-4.0017548e-016+dluapm
+ wua=7.6771918e-017+dwuapm pua=-2.3436565e-022+dpuapm
+ ub=4.5929185e-019         lub=-6.1684697e-026       wub=-4.8537429e-025
+ pub=7.378839e-031         uc=4.2390655e-011         luc=8.2688068e-017
+ wuc=-1.1713814e-017       puc=-2.9796207e-023       vsat=154924.05
+ lvsat=-0.020176661+dlvsatpm                         wvsat=-0.00055729877+dwvsatpm
+ pvsat=5.5554183e-009+dpvsatpm                       a0=1.5816755
+ la0=2.3819534e-007        wa0=4.0499422e-008        pa0=-1.2622321e-013
+ ags=0.61778775+dagspm     lags=-3.326518e-008       wags=2.0958488e-008
+ pags=7.1319251e-014       a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.037983593
+ lketa=-2.356053e-008      wketa=2.0683974e-009      pketa=-1.5237357e-029
+ dwg=0                     dwb=0                     pclm=-0.046001623
+ lpclm=6.9470457e-006+dlpclmpm                       wpclm=1.2901409e-007+dwpclmpm
+ ppclm=-1.2860736e-012+dppclmpm                      pdiblc1=0
+ pdiblc2=0.0043077948+dpdiblc2pm                     lpdiblc2=-2.4626245e-009+dlpdiblc2pm
+ wpdiblc2=-4.6374244e-010+dwpdiblc2pm                ppdiblc2=1.0969955e-015+dppdiblc2pm
+ pdiblcb=-0.2672938        lpdiblcb=1.9640846e-009   wpdiblcb=7.2075697e-008
+ ppdiblcb=-7.4148292e-014  drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.34100308
+ lkt1=-9.68629e-008        wkt1=6.4186708e-009       pkt1=1.5913365e-014
+ kt1l=0                    kt2=-0.0096909005         lkt2=-1.9282915e-008
+ wkt2=-1.1753432e-009      pkt2=-3.661785e-015       ute=-1.6211313
+ lute=1.6678533e-007       wute=2.9062719e-008       pute=-2.3385231e-014
+ ua1=2.6426146e-009        lua1=2.1206954e-015       wua1=-1.1104894e-016
+ pua1=-5.8976412e-022      ub1=-1.0015604e-017       lub1=-2.8505673e-024
+ wub1=6.5695709e-025       pub1=7.8369026e-031       uc1=-3.227112e-010
+ luc1=-2.6025035e-017      wuc1=7.6450508e-018       puc1=5.6523815e-023
+ prt=0                     at=350772.99              lat=-0.12568719
+ wat=-0.039319068          pat=2.8974872e-008        jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     15: type=p 
+ lmin=5e-007-dxlpm         lmax=1.2e-006-dxlpm       wmin=2.2e-07
+ wmax=5.3e-007-dxwpm       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.1433152+dvthpm    lvth0=-1.1548469e-008+dlvthpm
+ wvth0=-6.4690988e-009+dwvthpm                       pvth0=3.797722e-015+dpvthpm
+ k1=0.1926                 k2=0.081588009+dk2pm      lk2=-1.0034744e-008+dlk2pm
+ wk2=-8.0220446e-009+dwk2pm                          pk2=2.6435785e-015+dpk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022500001     lkvth0we=5.8000108e-011
+ wkvth0we=-3.8999949e-011  pkvth0we=-3.3697623e-023  k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00090240314+dcitpm
+ lcit=-9.2326397e-010+dlcitpm                        wcit=-4.6075645e-010+dwcitpm
+ pcit=3.3697621e-016+dpcitpm                         voff=-0.092510907+dvoffpm
+ lvoff=-1.2289855e-008+dlvoffpm                      wvoff=-4.405982e-009+dwvoffpm
+ pvoff=2.7867933e-015+dpvoffpm                       nfactor=0.55414909
+ lnfactor=2.0886956e-007+dlnfactorpm                 wnfactor=1.0789592e-007
+ pnfactor=-5.0546433e-014  eta0=0.091403658+deta0pm  leta0=5.5559303e-008+dleta0pm
+ weta0=2.8700315e-008+dweta0pm                       peta0=-1.3445351e-014+dpeta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.015670211            lu0=4.6369042e-010        wu0=2.3952894e-010
+ pu0=-1.1221308e-016       ua=1.955542e-009+duapm    lua=3.7816187e-016+dluapm
+ wua=-8.3023857e-017+dwuapm                          pua=-4.7648438e-023+dpuapm
+ ub=2.5816956e-019         lub=1.7332147e-025        wub=1.7438734e-025
+ pub=-3.3030409e-032       uc=2.1126503e-010         luc=-1.1463725e-016
+ wuc=-5.7611742e-017       puc=2.3834328e-023        vsat=127454.84
+ lvsat=0.011920398+dlvsatpm                          wvsat=0.0070060417+dwvsatpm
+ pvsat=-3.2821484e-009+dpvsatpm                      a0=2.5407793
+ la0=-8.8249255e-007       wa0=-2.1134465e-007       pa0=1.6805004e-013
+ ags=0.54536182+dagspm     lags=5.1362639e-008       wags=8.0994008e-008
+ pags=1.1693075e-015       a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.056240386
+ lketa=-2.227942e-009      wketa=1.6069734e-009      pketa=5.3916195e-016
+ dwg=0                     dwb=0                     pclm=9.6737674
+ lpclm=-4.4102517e-006+dlpclmpm                      wpclm=-1.8361479e-006+dwpclmpm
+ ppclm=1.0101671e-012+dppclmpm                       pdiblc1=0
+ pdiblc2=-0.0045649684+dpdiblc2pm                    lpdiblc2=7.9049686e-009+dlpdiblc2pm
+ wpdiblc2=2.1563988e-009+dwpdiblc2pm                 ppdiblc2=-1.9645714e-015+dppdiblc2pm
+ pdiblcb=-0.49972038       lpdiblcb=2.735485e-007    wpdiblcb=1.0090313e-007
+ ppdiblcb=-1.0783239e-013  drout=0.5                 pvag=0.895
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.4812818
+ lkt1=6.7049146e-008       wkt1=4.5358242e-008       pkt1=-2.9586512e-014
+ kt1l=0                    kt2=-0.0259597            lkt2=-2.7324578e-010
+ wkt2=-4.5860157e-009      pkt2=3.2349717e-016       ute=-1.7780485
+ lute=3.5013904e-007       wute=8.431903e-008        pute=-8.7950794e-014
+ ua1=4.1672221e-009        lua1=3.3923113e-016       wua1=-6.247193e-016
+ pua1=1.044633e-023        ub1=-1.3408286e-017       lub1=1.1136935e-024
+ wub1=1.7573538e-024       pub1=-5.0209464e-031      uc1=-4.7008717e-010
+ luc1=1.4617995e-016       wuc1=9.0424027e-017       puc1=-4.0201267e-023
+ prt=0                     at=280686.54              lat=-0.04379299
+ wat=-0.030296814          pat=1.8432603e-008        jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  saref=1.00e-05
+ sbref=1.00e-05            fnoimod=1                 noia=noiap_m
+ noib=noibp_m              noic=noicp_m              em=2.10e7
+ ef=1.12                   minr=1e-3
 
 
 
     16: type=p 
+ lmin=2.5e-07              lmax=5e-007-dxlpm         wmin=2.2e-07
+ wmax=5.3e-007-dxwpm       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxpm                toxm=toxpm
+ dtox=4.896e-010           epsrox=3.9                wint=-1.1e-008
+ lint=8.263e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlpm
+ xw=0+dxwpm                dlc=dlcpm                 dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.18140812+dvthpm   lvth0=6.2970702e-009+dlvthpm
+ wvth0=7.4171519e-009+dwvthpm                        pvth0=-2.7076254e-015+dpvthpm
+ k1=0.1926                 k2=0.056367717+dk2pm      lk2=1.7803066e-009+dlk2pm
+ wk2=-4.9795715e-010+dwk2pm                          pk2=-8.8126087e-016+dpk2pm
+ k3=0.1                    k3b=0.1                   w0=0
+ dvt0=9.8                  dvt1=1.38                 dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.3                 voffl=0
+ dvtp0=4.617e-006          dvtp1=1.1                 lpe0=6.841e-008
+ lpeb=1.217e-007           web=0                     wec=0
+ scref=1e-006              kvth0we=-0.0022650892     lkvth0we=6.5068925e-011
+ wkvth0we=-3.067071e-011   pkvth0we=-3.9020657e-018  k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=7.65e+019           ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0023958264+dcitpm
+ lcit=6.2187081e-010+dlcitpm                         wcit=6.0345414e-010+dwcitpm
+ pcit=-1.6157878e-016+dpcitpm                        voff=-0.11914358+dvoffpm
+ lvoff=1.8685885e-010+dlvoffpm                       wvoff=3.8467817e-009+dwvoffpm
+ pvoff=-1.0794119e-015+dpvoffpm                      nfactor=1
+ eta0=0.13511485+deta0pm   leta0=3.5081744e-008+dleta0pm
+ weta0=4.2132546e-008+dweta0pm                       peta0=-1.9738002e-014+dpeta0pm
+ etab=-0.05096             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.017654768            lu0=-4.6602309e-010       wu0=-3.8847604e-010
+ pu0=1.8199092e-016        ua=3.5975652e-009+duapm   lua=-3.9108333e-016+dluapm
+ wua=-4.1337021e-016+dwuapm                          pua=1.0711024e-022+dpuapm
+ ub=-6.7942838e-019        lub=6.1256173e-025        wub=3.3585369e-025
+ pub=-1.086732e-031        uc=-1.5964568e-010        luc=5.9124775e-017
+ wuc=3.4262662e-017        puc=-1.9206441e-023       vsat=144081.64
+ lvsat=0.0041311722+dlvsatpm                         wvsat=0.010482761+dwvsatpm
+ pvsat=-4.910901e-009+dpvsatpm                       a0=0.40280244
+ la0=1.1909401e-007        wa0=1.9218771e-007        pa0=-2.099438e-014
+ ags=0.33665966+dagspm     lags=1.4913417e-007       wags=2.7737587e-007
+ pags=-9.083049e-014       a1=0                      a2=0.5705
+ b0=0                      b1=0                      keta=-0.053436542
+ lketa=-3.54147e-009       wketa=-5.4672574e-010     pketa=1.548114e-015
+ dwg=0                     dwb=0                     pclm=-0.14143722
+ lpclm=1.879165e-007+dlpclmpm                        wpclm=5.6982411e-007+dwpclmpm
+ ppclm=-1.1696825e-013+dppclmpm                      pdiblc1=0
+ pdiblc2=0.020213556+dpdiblc2pm                      lpdiblc2=-3.703126e-009+dlpdiblc2pm
+ wpdiblc2=-3.4056526e-009+dwpdiblc2pm                ppdiblc2=6.4110509e-016+dppdiblc2pm
+ pdiblcb=0.28376547        lpdiblcb=-9.3494251e-008  wpdiblcb=-2.5391025e-007
+ ppdiblcb=5.838845e-014    drout=0.5                 pvag=0.895
