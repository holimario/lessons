+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0.017               pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=140                   rdw=140                   prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=2.593e-009
+ bgidl=2.5204e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgopm                cgdo=cgopm                cgbo=0
+ cgdl=cglpm                cgsl=cglpm                clc=1e-007
+ cle=0.6                   cf=cfpm                   ckappas=0.6
+ ckappad=0.6               acde=0.3322               moin=9.77
+ noff=1.919                voffcv=-0.0543            kt1=-0.31123593
+ lkt1=-1.2612922e-008      wkt1=-2.9908938e-008      pkt1=5.6742046e-015
+ kt1l=0                    kt2=0.0022795324          lkt2=-1.3502592e-008
+ wkt2=-1.6443239e-008      pkt2=5.8782982e-015       ute=-1.7002527
+ lute=3.1369373e-007       wute=4.6860511e-008       pute=-7.0402452e-014
+ ua1=-1.1665569e-009       lua1=2.8379679e-015       wua1=1.2596353e-015
+ pua1=-8.723248e-022       ub1=-5.2240365e-018       lub1=-2.7204144e-024
+ wub1=-1.3761119e-024      pub1=9.6585254e-031       uc1=-2.296169e-010
+ luc1=3.352588e-017        wuc1=4.2811689e-017       puc1=-1.7896124e-023
+ prt=0                     at=319506.63              lat=-0.061979192
+ wat=0.021132548           pat=-5.6607162e-009       jss=1.48e-07
+ jsd=1.48e-07              jsws=4.06e-13             jswd=4.06e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.1
+ bvd=11.1                  xjbvs=1                   xjbvd=1
+ pbs=0.886                 pbd=0.886                 cjs=cjpm
+ cjd=cjpm                  mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswpm
+ cjswd=cjswpm              mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgpm
+ cjswgd=cjswgpm            mjswgs=0.70189            mjswgd=0.70189
+ tpb=0.00161               tcj=9.18e-04              tpbsw=0.00125
+ tcjsw=8.86e-04            tpbswg=0.00115            tcjswg=0.00158
+ xtis=3                    xtid=3                    jtsswgs=5.4876e-010
+ jtsswgd=5.4876e-010       dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wlod=5e-006               kvth0=-2.3e-009
+ lkvth0=5e-008             wkvth0=2.5e-007           pkvth0=4e-014
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=4.8e-008
+ lku0=2.5e-007             wku0=1e-008               pku0=-1e-012
+ llodku0=1                 wlodku0=1                 kvsat=-0.6
+ steta0=0                  tku0=0.5                  lnfactor=0+dlnfactorpm
+ saref=1.00e-05            sbref=1.00e-05            fnoimod=1
+ noia=noiap_m              noib=noibp_m              noic=noicp_m
+ em=2.10e7                 ef=1.12                   minr=1e-3
 
 
 
     } 
endsection mos_m
// *********************************************************************************************
// 

section mos_5m
// *********************************************************************************************
//                                                                            
//                   *
//                                 5V MED-VT NMOS DEVICE MODELS               
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
// *********************************
//        Macro   model            *
// *********************************
 
inline subckt mench5_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2e-007 dmci=2e-007 
+ xw=1e-08 + dxwn_5m ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf 
+ * dmcg + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor 
+ + (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 
+ 1) * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=0 / factor sb=0 / factor sd=2 * dmcg 
+ / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_5m 
+ temp1=par1n_5m temp2=par2n_5m fac1=0.015227 * temp1 * sigma + 0.999884 * temp2 
+ * sigma fac2=0.015227 * temp1 * sigma - 0.999884 * temp2 * sigma lef=l * factor 
+ - 3e-08 wef=w / nf * factor + 1e-08 geo_fac=1 / sqrt(multi * nf * lef * wef * 
+ 1e12) vthmisn_5m=7.982e-3 * geo_fac * fac1 * mismatchflag dlmisn_5m=2.579e-3 * 
+ geo_fac * lef * fac2 * mismatchflag dwmisn_5m= - 2.579e-3 * geo_fac * wef * fac2 
+ * mismatchflag toxmisn_5m=2.579e-3 * geo_fac * toxn_5m * fac2 * mismatchflag 
mench5_mac ( n1 n2 n3 n4 ) mench5 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
 
model mench5 bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_5m+dlmisn_5m                       lmax=900.01e-6
+ wmin=1e-005-dxwn_5m+dwmisn_5m                       wmax=900.01e-6
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.41+dvthn_5m+vthmisn_5m
+ k1=0.585                  k2=0.05255+dk2n_5m        k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00016
+ voff=-0.094245            nfactor=0.5               eta0=0.001
+ etab=-0.3557              ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.056568+du0n_5m
+ ua=7.15e-010              ub=2.0138e-018            uc=6.5388e-011
+ vsat=85000                a0=1.4                    ags=0.189
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.018556            dwg=0
+ dwb=0                     pclm=0.099988             pdiblc1=0
+ pdiblc2=0.00011           pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.005               pscbe1=3.9e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=651.4                prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=39
+ beta0=42.8                agidl=1e-014              bgidl=7.5e+008
+ cgidl=0.5                 egidl=0.26                aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_5m
+ cgdo=cgon_5m              cgbo=0                    cgdl=cgln_5m
+ cgsl=cgln_5m              clc=1e-007                cle=0.6
+ cf=cfn_5m                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7                    noff=2.5
+ voffcv=-0.05              tvoff=0.0022215959        ltvoff=0
+ wtvoff=0                  ptvoff=0                  kt1=-0.31561
+ kt1l=0                    kt2=-0.043125392          ute=-1.6694
+ ua1=1.2666e-009           ub1=-1.6092e-018          uc1=2.0802e-011
+ prt=0                     at=63159.41               fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.00
+ noia=2e+41                noib=1e+22                noic=1e+6
+ lintnoi=1.0e-7            jss=4.865e-7              jsd=4.865e-7
+ jsws=2.498e-12            jswd=2.498e-12            jswgs=1e-012
+ jswgd=1e-012              njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.3                   bvd=9.3
+ xjbvs=1                   xjbvd=1                   jtsswgs=8.75e-010
+ jtsswgd=8.75e-010         njtsswg=39                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.702                 pbd=0.702
+ cjs=cjn_5m                cjd=cjn_5m                mjs=0.308
+ mjd=0.308                 pbsws=0.394               pbswd=0.394
+ cjsws=cjswn_5m            cjswd=cjswn_5m            mjsws=0.096
+ mjswd=0.096               pbswgs=0.574              pbswgd=0.574
+ cjswgs=cjswgn_5m          cjswgd=cjswgn_5m          mjswgs=0.238
+ mjswgd=0.238              tpb=1.4e-3                tcj=7.372e-4
+ tpbsw=1.6e-3              tcjsw=5.458e-4            tpbswg=4.40e-4
+ tcjswg=3.95e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lvth0=0+dlvthn_5m
+ wvth0=0+dwvthn_5m         pvth0=0+dpvthn_5m         wu0=0+dwu0n_5m
+ lu0=0+dlu0n_5m            pu0=0+dpu0n_5m            lk2=0+dlk2n_5m
+ lvsat=0+dlvsatn_5m        pvsat=0+dpvsatn_5m        rshg=8.23
+ minr=1e-3
 
     2: type=n 
+ lmin=1.2e-006-dxln_5m+dlmisn_5m                     lmax=1e-005-dxln_5m+dlmisn_5m
+ wmin=1e-005-dxwn_5m+dwmisn_5m                       wmax=900.01e-6
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.40953727+dvthn_5m+vthmisn_5m
+ lvth0=4.5430564e-009+dlvthn_5m                      k1=0.585
+ k2=0.051977375+dk2n_5m    lk2=5.6220323e-009+dlk2n_5m
+ k3=-2.011                 k3b=0.41625               w0=0
+ dvt0=3.6                  dvt1=0.21214              dvt2=0.025
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.296               voffl=0
+ dvtp0=1e-006              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=5.0535e-008          xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00016115682         lcit=-1.1357641e-011      voff=-0.094240373
+ lvoff=-4.5430564e-011     nfactor=0.5               eta0=0.001
+ etab=-0.3557              ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.055823935+du0n_5m
+ lu0=7.3052346e-009+dlu0n_5m                         ua=7.2113114e-010
+ lua=-6.0195497e-017       ub=2.0291394e-018         lub=-1.5060232e-025
+ uc=6.6919049e-011         luc=-1.5031838e-017       vsat=85335.477
+ lvsat=-0.0032937159+dlvsatn_5m                      a0=1.4925455
+ la0=-9.0861126e-007       ags=0.19929568            lags=-1.01083e-007
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.018606784         lketa=4.9860044e-010
+ dwg=0                     dwb=0                     pclm=0.091888885
+ lpclm=7.9517116e-008      pdiblc1=0                 pdiblc2=0.00011115682
+ lpdiblc2=-1.1357641e-011  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.005               pscbe1=3.9e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=651.4                prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=39
+ beta0=42.8                agidl=1e-014              bgidl=7.5e+008
+ cgidl=0.5                 egidl=0.26                aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_5m
+ cgdo=cgon_5m              cgbo=0                    cgdl=cgln_5m
+ cgsl=cgln_5m              clc=1e-007                cle=0.6
+ cf=cfn_5m                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7                    noff=2.5
+ voffcv=-0.05              tvoff=0.0021963391        ltvoff=2.4797092e-010
+ wtvoff=0                  ptvoff=0                  kt1=-0.31341552
+ lkt1=-2.1545445e-008      kt1l=0                    kt2=-0.04309856
+ lkt2=-2.6344162e-010      ute=-1.6889965            lute=1.9239844e-007
+ ua1=1.0941184e-009        lua1=1.6934242e-015       ub1=-1.4506234e-018
+ lub1=-1.5569054e-024      uc1=1.9272224e-011        luc1=1.501934e-017
+ prt=0                     at=70986.374              lat=-0.076845135
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.00                   noia=2e+41                noib=1e+22
+ noic=1e+6                 lintnoi=1.0e-7            jss=4.865e-7
+ jsd=4.865e-7              jsws=2.498e-12            jswd=2.498e-12
+ jswgs=1e-012              jswgd=1e-012              njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.3
+ bvd=9.3                   xjbvs=1                   xjbvd=1
+ jtsswgs=8.75e-010         jtsswgd=8.75e-010         njtsswg=39
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.702
+ pbd=0.702                 cjs=cjn_5m                cjd=cjn_5m
+ mjs=0.308                 mjd=0.308                 pbsws=0.394
+ pbswd=0.394               cjsws=cjswn_5m            cjswd=cjswn_5m
+ mjsws=0.096               mjswd=0.096               pbswgs=0.574
+ pbswgd=0.574              cjswgs=cjswgn_5m          cjswgd=cjswgn_5m
+ mjswgs=0.238              mjswgd=0.238              tpb=1.4e-3
+ tcj=7.372e-4              tpbsw=1.6e-3              tcjsw=5.458e-4
+ tpbswg=4.40e-4            tcjswg=3.95e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthn_5m         pvth0=0+dpvthn_5m         wu0=0+dwu0n_5m
+ pu0=0+dpu0n_5m            pvsat=0+dpvsatn_5m        rshg=8.23
+ minr=1e-3
 
     3: type=n 
+ lmin=8.0e-07              lmax=1.2e-006-dxln_5m+dlmisn_5m
+ wmin=1e-005-dxwn_5m+dwmisn_5m                       wmax=900.01e-6
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.36455999+dvthn_5m+vthmisn_5m
+ lvth0=5.0329936e-008+dlvthn_5m                      k1=0.585
+ k2=0.04514+dk2n_5m        lk2=1.258248e-008+dlk2n_5m
+ k3=-2.011                 k3b=0.41625               w0=0
+ dvt0=3.6                  dvt1=0.21214              dvt2=0.025
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.296               voffl=0
+ dvtp0=1e-006              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=5.0535e-008          xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=8.82e-005             lcit=6.29124e-011         voff=-0.10090532
+ lvoff=6.7394893e-009      nfactor=0.5               eta0=0.001
+ etab=-0.3557              ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.054534945+du0n_5m
+ lu0=8.617426e-009+dlu0n_5m                          ua=2.21675e-010
+ lua=4.4825085e-016        ub=3.1899695e-018         lub=-1.3323274e-024
+ uc=8.8628905e-011         luc=-3.7132471e-017       vsat=97550
+ lvsat=-0.0157281+dlvsatn_5m                         a0=1.5579001
+ la0=-9.751423e-007        ags=0.1                   a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.0097627601        lketa=-8.5046162e-009     dwg=0
+ dwb=0                     pclm=-0.21625             lpclm=3.932025e-007
+ pdiblc1=0                 pdiblc2=-0.00098149997    lpdiblc2=1.100967e-009
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.005               pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=39                 beta0=42.8
+ agidl=1e-014              bgidl=7.5e+008            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5m              cgdo=cgon_5m
+ cgbo=0                    cgdl=cgln_5m              cgsl=cgln_5m
+ clc=1e-007                cle=0.6                   cf=cfn_5m
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.0032887901        ltvoff=-8.6414412e-010    wtvoff=0
+ ptvoff=0                  kt1=-0.27953423           lkt1=-5.6036594e-008
+ kt1l=0                    kt2=-0.054796089          lkt2=1.1644643e-008
+ ute=-1.5                  ua1=1.7431528e-009        lua1=1.0327072e-015
+ ub1=-1.7494075e-018       lub1=-1.2527432e-024      uc1=7.5149255e-011
+ luc1=-4.1863478e-017      prt=0                     at=-36126.166
+ lat=0.032195431           fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.00                   noia=2e+41
+ noib=1e+22                noic=1e+6                 lintnoi=1.0e-7
+ jss=4.865e-7              jsd=4.865e-7              jsws=2.498e-12
+ jswd=2.498e-12            jswgs=1e-012              jswgd=1e-012
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.3                   bvd=9.3                   xjbvs=1
+ xjbvd=1                   jtsswgs=8.75e-010         jtsswgd=8.75e-010
+ njtsswg=39                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.702                 pbd=0.702                 cjs=cjn_5m
+ cjd=cjn_5m                mjs=0.308                 mjd=0.308
+ pbsws=0.394               pbswd=0.394               cjsws=cjswn_5m
+ cjswd=cjswn_5m            mjsws=0.096               mjswd=0.096
+ pbswgs=0.574              pbswgd=0.574              cjswgs=cjswgn_5m
+ cjswgd=cjswgn_5m          mjswgs=0.238              mjswgd=0.238
+ tpb=1.4e-3                tcj=7.372e-4              tpbsw=1.6e-3
+ tcjsw=5.458e-4            tpbswg=4.40e-4            tcjswg=3.95e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wvth0=0+dwvthn_5m         pvth0=0+dpvthn_5m
+ wu0=0+dwu0n_5m            pu0=0+dpu0n_5m            pvsat=0+dpvsatn_5m
+ rshg=8.23                 minr=1e-3
 
     4: type=n 
+ lmin=1e-005-dxln_5m+dlmisn_5m                       lmax=900.01e-6
+ wmin=1.2e-006-dxwn_5m+dwmisn_5m                     wmax=1e-005-dxwn_5m+dwmisn_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.409725+dvthn_5m+vthmisn_5m
+ wvth0=2.75275e-009+dwvthn_5m                        k1=0.585
+ k2=0.052488125+dk2n_5m    wk2=6.1936875e-010        k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.000129475
+ wcit=3.0555525e-010       voff=-0.093453688         wvoff=-7.9210381e-009
+ nfactor=0.5               eta0=0.0008626375         weta0=1.3749986e-009
+ etab=-0.3558375           wetab=1.376375e-009       ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.0574711+du0n_5m      wu0=-9.040031e-009+dwu0n_5m
+ ua=6.9135e-010            wua=2.367365e-016         ub=2.1045913e-018
+ wub=-9.0882041e-025       uc=6.9914225e-011         wuc=-4.5307512e-017
+ vsat=84972.5              wvsat=0.000275275         a0=1.434375
+ wa0=-3.4409375e-007       ags=0.191475              wags=-2.477475e-008
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.019698763         wketa=1.1439053e-008
+ dwg=0                     dwb=0                     pclm=0.10823635
+ wpclm=-8.2565984e-008     pdiblc1=0                 pdiblc2=0.000121
+ wpdiblc2=-1.1011e-010     pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.005               pscbe1=3.9e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=651.4                prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=39
+ beta0=42.8                agidl=-2.37775e-015       wagidl=1.2390128e-019
+ bgidl=7.5e+008            cgidl=0.5                 egidl=0.26
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_5m              cgdo=cgon_5m              cgbo=0
+ cgdl=cgln_5m              cgsl=cgln_5m              clc=1e-007
+ cle=0.6                   cf=cfn_5m                 ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7
+ noff=2.5                  voffcv=-0.05              tvoff=0.0024793172
+ ltvoff=0                  wtvoff=-2.5797902e-009    ptvoff=0
+ kt1=-0.31193463           wkt1=-3.6790504e-008      kt1l=0
+ kt2=-0.042613889          wkt2=-5.1201425e-009      ute=-1.6926925
+ wute=2.3315793e-007       ua1=1.3504351e-009        wua1=-8.391896e-016
+ ub1=-1.778996e-018        wub1=1.699658e-024        uc1=2.1333988e-011
+ wuc1=-5.3251949e-018      prt=0                     at=61131.286
+ wat=0.020301526           fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.00                   noia=2e+41
+ noib=1e+22                noic=1e+6                 lintnoi=1.0e-7
+ jss=4.865e-7              jsd=4.865e-7              jsws=2.498e-12
+ jswd=2.498e-12            jswgs=1e-012              jswgd=1e-012
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.3                   bvd=9.3                   xjbvs=1
+ xjbvd=1                   jtsswgs=8.75e-010         jtsswgd=8.75e-010
+ njtsswg=39                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.702                 pbd=0.702                 cjs=cjn_5m
+ cjd=cjn_5m                mjs=0.308                 mjd=0.308
+ pbsws=0.394               pbswd=0.394               cjsws=cjswn_5m
+ cjswd=cjswn_5m            mjsws=0.096               mjswd=0.096
+ pbswgs=0.574              pbswgd=0.574              cjswgs=cjswgn_5m
+ cjswgd=cjswgn_5m          mjswgs=0.238              mjswgd=0.238
+ tpb=1.4e-3                tcj=7.372e-4              tpbsw=1.6e-3
+ tcjsw=5.458e-4            tpbswg=4.40e-4            tcjswg=3.95e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthn_5m         pvth0=0+dpvthn_5m
+ lu0=0+dlu0n_5m            pu0=0+dpu0n_5m            lk2=0+dlk2n_5m
+ lvsat=0+dlvsatn_5m        pvsat=0+dpvsatn_5m        rshg=8.23
+ minr=1e-3
 
     5: type=n 
+ lmin=1.2e-006-dxln_5m+dlmisn_5m                     lmax=1e-005-dxln_5m+dlmisn_5m
+ wmin=1.2e-006-dxwn_5m+dwmisn_5m                     wmax=1e-005-dxwn_5m+dwmisn_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.40926227+dvthn_5m+vthmisn_5m
+ lvth0=4.5430564e-009+dlvthn_5m                      wvth0=2.75275e-009+dwvthn_5m
+ pvth0=1.9076232e-029+dpvthn_5m                      k1=0.585
+ k2=0.051868577+dk2n_5m    lk2=6.0827264e-009+dlk2n_5m
+ wk2=1.0890722e-009        pk2=-4.6115485e-015       k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00012869126
+ lcit=7.6948017e-012       wcit=3.2498028e-010       pcit=-1.9071495e-016
+ voff=-0.093527955         lvoff=7.2916055e-010      wvoff=-7.1312992e-009
+ pvoff=-7.753657e-015      nfactor=0.5               eta0=0.0008626375
+ weta0=1.3749986e-009      etab=-0.3558375           wetab=1.376375e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.056704257+du0n_5m    lu0=7.5288666e-009+dlu0n_5m
+ wu0=-8.8120257e-009+dwu0n_5m                        pu0=-2.2385558e-015+dpu0n_5m
+ ua=6.9808557e-010         lua=-6.6129864e-017       wua=2.3068608e-016
+ pua=5.9403017e-023        ub=2.1141446e-018         lub=-9.3794806e-026
+ wub=-8.5090198e-025       pub=-5.686432e-031        uc=7.1434903e-011
+ luc=-1.4930017e-017       wuc=-4.52037e-017         puc=-1.0192307e-024
+ vsat=85325.474            lvsat=-0.0034655002+dlvsatn_5m
+ wvsat=0.00010013128       pvsat=1.719561e-009+dpvsatn_5m
+ a0=1.5293064              la0=-9.320364e-007        wa0=-3.6797698e-007
+ pa0=2.344856e-013         ags=0.20348856            lags=-1.179491e-007
+ wags=-4.197068e-008       pags=1.6882964e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.020120051         lketa=4.1362115e-009      wketa=1.5147801e-008
+ pketa=-3.6412486e-014     dwg=0                     dwb=0
+ pclm=0.10196626           lpclm=6.155972e-008       wpclm=-1.0087455e-007
+ ppclm=1.7975353e-013      pdiblc1=0                 pdiblc2=0.00012263401
+ lpdiblc2=-1.6042668e-011  wpdiblc2=-1.1488665e-010  ppdiblc2=4.6897122e-017
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.005               pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=39                 beta0=42.8
+ agidl=-1.9174231e-015     lagidl=-4.5194893e-021    wagidl=1.1929341e-019
+ pagidl=4.5240088e-026     bgidl=7.5e+008            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5m              cgdo=cgon_5m
+ cgbo=0                    cgdl=cgln_5m              cgsl=cgln_5m
+ clc=1e-007                cle=0.6                   cf=cfn_5m
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00246445          ltvoff=1.4596592e-010     wtvoff=-2.68379e-009
+ ptvoff=1.0210701e-015     kt1=-0.30946369           lkt1=-2.4259637e-008
+ wkt1=-3.9557775e-008      pkt1=2.7169064e-014       kt1l=0
+ kt2=-0.042546061          lkt2=-6.6594196e-010      wkt2=-5.5305141e-009
+ pkt2=4.0290284e-015       ute=-1.7149835            lute=2.1885322e-007
+ wute=2.6013006e-007       pute=-2.648124e-013       ua1=1.1613365e-009
+ lua1=1.8565708e-015       wua1=-6.7285243e-016      pua1=-1.6330984e-021
+ ub1=-1.6033588e-018       lub1=-1.7244061e-024      wub1=1.5288817e-024
+ pub1=1.6766815e-030       uc1=2.0241872e-011        luc1=1.0722389e-017
+ wuc1=-9.7061762e-018      puc1=4.3012474e-023       prt=0
+ at=68908.128              lat=-0.076353036          wat=0.020803249
+ pat=-4.9259189e-009       fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.00                   noia=2e+41
+ noib=1e+22                noic=1e+6                 lintnoi=1.0e-7
+ jss=4.865e-7              jsd=4.865e-7              jsws=2.498e-12
+ jswd=2.498e-12            jswgs=1e-012              jswgd=1e-012
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.3                   bvd=9.3                   xjbvs=1
+ xjbvd=1                   jtsswgs=8.75e-010         jtsswgd=8.75e-010
+ njtsswg=39                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.702                 pbd=0.702                 cjs=cjn_5m
+ cjd=cjn_5m                mjs=0.308                 mjd=0.308
+ pbsws=0.394               pbswd=0.394               cjsws=cjswn_5m
+ cjswd=cjswn_5m            mjsws=0.096               mjswd=0.096
+ pbswgs=0.574              pbswgd=0.574              cjswgs=cjswgn_5m
+ cjswgd=cjswgn_5m          mjswgs=0.238              mjswgd=0.238
+ tpb=1.4e-3                tcj=7.372e-4              tpbsw=1.6e-3
+ tcjsw=5.458e-4            tpbswg=4.40e-4            tcjswg=3.95e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   rshg=8.23                 minr=1e-3
 
     6: type=n 
+ lmin=8.0e-07              lmax=1.2e-006-dxln_5m+dlmisn_5m
+ wmin=1.2e-006-dxwn_5m+dwmisn_5m                     wmax=1e-005-dxwn_5m+dwmisn_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.36725911+dvthn_5m+vthmisn_5m
+ lvth0=4.7302277e-008+dlvthn_5m                      wvth0=-2.7018241e-008+dwvthn_5m
+ pvth0=3.0306869e-014+dpvthn_5m                      k1=0.585
+ k2=0.044846437+dk2n_5m    lk2=1.3231264e-008+dlk2n_5m
+ wk2=2.9385641e-009        pk2=-6.4943313e-015       k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=6.7227125e-005
+ lcit=7.0265287e-011       wcit=2.0993848e-010       pcit=-7.3602396e-017
+ voff=-0.10352887          lvoff=1.091009e-008       wvoff=2.626168e-008
+ pvoff=-4.174771e-014      nfactor=0.5               eta0=0.0008626375
+ weta0=1.3749986e-009      etab=-0.3558375           wetab=1.376375e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.054895875+du0n_5m    lu0=9.3697993e-009+dlu0n_5m
+ wu0=-3.6129087e-009+dwu0n_5m                        pu0=-7.531257e-015+dpu0n_5m
+ ua=9.5078754e-011         lua=5.4773108e-016        wua=1.2672284e-015
+ pua=-9.9579708e-022       ub=3.4914973e-018         lub=-1.4959399e-024
+ wub=-3.0182937e-024       pub=1.6377615e-030        uc=9.2153276e-011
+ luc=-3.602132e-017        wuc=-3.5278955e-017       puc=-1.1122621e-023
+ vsat=98263.488            lvsat=-0.016636398+dlvsatn_5m
+ wvsat=-0.0071420099       pvsat=9.0920607e-009+dpvsatn_5m
+ a0=1.5758989              la0=-9.7946753e-007       wa0=-1.8016748e-007
+ pa0=4.3295514e-014        ags=0.089749372           lags=-2.1626116e-009
+ wags=1.0260879e-007       pags=2.1647742e-014       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.0063528488        lketa=-9.8788004e-009     wketa=-3.4133212e-008
+ pketa=1.3755584e-014      dwg=0                     dwb=0
+ pclm=-0.22699906          lpclm=3.9644642e-007      wpclm=1.0759809e-007
+ ppclm=-3.2471624e-014     pdiblc1=0                 pdiblc2=-0.00090027184
+ lpdiblc2=1.0252755e-009   wpdiblc2=-8.1309357e-010  ppdiblc2=7.5767177e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.005               pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=39                 beta0=42.8
+ agidl=-6.357e-015         wagidl=1.6373357e-019     bgidl=7.5e+008
+ cgidl=0.5                 egidl=0.26                aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_5m
+ cgdo=cgon_5m              cgbo=0                    cgdl=cgln_5m
+ cgsl=cgln_5m              clc=1e-007                cle=0.6
+ cf=cfn_5m                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7                    noff=2.5
+ voffcv=-0.05              tvoff=0.0032858011        ltvoff=-6.901695e-010
+ wtvoff=2.99193e-011       ptvoff=-1.741486e-015     kt1=-0.28035533
+ lkt1=-5.3891949e-008      wkt1=8.2191967e-009       pkt1=-2.1467892e-014
+ kt1l=0                    kt2=-0.055220672          lkt2=1.2236812e-008
+ wkt2=4.2500738e-009       pkt2=-5.9276101e-015      ute=-1.4356952
+ lute=-6.5462318e-008      wute=-6.4369136e-007      pute=6.5527781e-013
+ ua1=2.3349631e-009        lua1=6.6181892e-016       wua1=-5.9240214e-015
+ pua1=3.7125917e-021       ub1=-2.3618744e-018       lub1=-9.5223717e-025
+ wub1=6.1307938e-024       pub1=-3.008065e-030       uc1=7.7552379e-011
+ luc1=-4.7619707e-017      wuc1=-2.4055269e-017      puc1=5.7619851e-023
+ prt=0                     at=-39872.346             lat=0.034385487
+ wat=0.037499264           pat=-2.1922463e-008       fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.00
+ noia=2e+41                noib=1e+22                noic=1e+6
+ lintnoi=1.0e-7            jss=4.865e-7              jsd=4.865e-7
+ jsws=2.498e-12            jswd=2.498e-12            jswgs=1e-012
+ jswgd=1e-012              njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.3                   bvd=9.3
+ xjbvs=1                   xjbvd=1                   jtsswgs=8.75e-010
+ jtsswgd=8.75e-010         njtsswg=39                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.702                 pbd=0.702
+ cjs=cjn_5m                cjd=cjn_5m                mjs=0.308
+ mjd=0.308                 pbsws=0.394               pbswd=0.394
+ cjsws=cjswn_5m            cjswd=cjswn_5m            mjsws=0.096
+ mjswd=0.096               pbswgs=0.574              pbswgd=0.574
+ cjswgs=cjswgn_5m          cjswgd=cjswgn_5m          mjswgs=0.238
+ mjswgd=0.238              tpb=1.4e-3                tcj=7.372e-4
+ tpbsw=1.6e-3              tcjsw=5.458e-4            tpbswg=4.40e-4
+ tcjswg=3.95e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   rshg=8.23
+ minr=1e-3
 
     7: type=n 
+ lmin=1e-005-dxln_5m+dlmisn_5m                       lmax=900.01e-6
+ wmin=5e-007-dxwn_5m+dwmisn_5m                       wmax=1.2e-006-dxwn_5m+dwmisn_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.41637143+dvthn_5m+vthmisn_5m
+ wvth0=-5.2894286e-009+dwvthn_5m                     k1=0.585
+ k2=0.052635714+dk2n_5m    wk2=4.4078571e-010        k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00041988571
+ wcit=-4.5841714e-011      voff=-0.10145714          wvoff=1.7631429e-009
+ nfactor=0.5               eta0=0.0012711571         weta0=8.8068986e-010
+ etab=-0.87985429          wetab=6.3543669e-007      ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.050710357+du0n_5m    wu0=-8.5953214e-010+dwu0n_5m
+ ua=8.9938571e-010         wua=-1.4986714e-017       ub=1.3966314e-018
+ wub=-5.2189029e-026       uc=5.0134214e-011         wuc=-2.1373699e-017
+ vsat=84981.429            wvsat=0.00026447143       a0=1.1864286
+ wa0=-4.4078571e-008       ags=0.17755714            wags=-7.9341429e-009
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.0071726143        wketa=-3.7175867e-009
+ dwg=0                     dwb=0                     pclm=0.054571429
+ wpclm=-1.7631429e-008     pdiblc1=0                 pdiblc2=4.4571429e-005
+ wpdiblc2=-1.7631429e-011  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.005               pscbe1=3.9e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=651.4                prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=39
+ beta0=42.8                agidl=1.0002e-013         bgidl=7.5e+008
+ cgidl=0.5                 egidl=0.26                aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_5m
+ cgdo=cgon_5m              cgbo=0                    cgdl=cgln_5m
+ cgsl=cgln_5m              clc=1e-007                cle=0.6
+ cf=cfn_5m                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7                    noff=2.5
+ voffcv=-0.05              tvoff=0.0011384606        ltvoff=0
+ wtvoff=-9.5735376e-010    ptvoff=0                  kt1=-0.34283715
+ wkt1=6.0154908e-010       kt1l=0                    kt2=-0.046082598
+ wkt2=-9.230044e-010       ute=-1.6500857            wute=1.8160371e-007
+ ua1=-3.54593e-010         wua1=1.2238944e-015       ub1=1.1443726e-018
+ wub1=-1.837618e-024       uc1=5.1127043e-011        wuc1=-4.1374792e-017
+ prt=0                     at=92284.115              wat=-0.017393397
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.00                   noia=2e+41                noib=1e+22
+ noic=1e+6                 lintnoi=1.0e-7            jss=4.865e-7
+ jsd=4.865e-7              jsws=2.498e-12            jswd=2.498e-12
+ jswgs=1e-012              jswgd=1e-012              njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.3
+ bvd=9.3                   xjbvs=1                   xjbvd=1
+ jtsswgs=8.75e-010         jtsswgd=8.75e-010         njtsswg=39
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.702
+ pbd=0.702                 cjs=cjn_5m                cjd=cjn_5m
+ mjs=0.308                 mjd=0.308                 pbsws=0.394
+ pbswd=0.394               cjsws=cjswn_5m            cjswd=cjswn_5m
+ mjsws=0.096               mjswd=0.096               pbswgs=0.574
+ pbswgd=0.574              cjswgs=cjswgn_5m          cjswgd=cjswgn_5m
+ mjswgs=0.238              mjswgd=0.238              tpb=1.4e-3
+ tcj=7.372e-4              tpbsw=1.6e-3              tcjsw=5.458e-4
+ tpbswg=4.40e-4            tcjswg=3.95e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lvth0=0+dlvthn_5m         pvth0=0+dpvthn_5m         lu0=0+dlu0n_5m
+ pu0=0+dpu0n_5m            lk2=0+dlk2n_5m            lvsat=0+dlvsatn_5m
+ pvsat=0+dpvsatn_5m        rshg=8.23                 minr=1e-3
 
     8: type=n 
+ lmin=1.2e-006-dxln_5m+dlmisn_5m                     lmax=1e-005-dxln_5m+dlmisn_5m
+ wmin=5e-007-dxwn_5m+dwmisn_5m                       wmax=1.2e-006-dxwn_5m+dwmisn_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.41666724+dvthn_5m+vthmisn_5m
+ lvth0=-2.904311e-009+dlvthn_5m                      wvth0=-6.2072646e-009+dwvthn_5m
+ pvth0=9.0113146e-015+dpvthn_5m                      k1=0.585
+ k2=0.052151503+dk2n_5m    lk2=4.7539859e-009+dlk2n_5m
+ wk2=7.4673117e-010        pk2=-3.0037725e-015       k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00043532428
+ lcit=-1.5157583e-010      wcit=-4.6045678e-011      pcit=2.0025143e-018
+ voff=-0.10146871          lvoff=1.1357641e-010      wvoff=2.4770154e-009
+ pvoff=-7.0088002e-015     nfactor=0.5               eta0=0.0012711571
+ weta0=8.8068986e-010      etab=-0.87985429          wetab=6.3543669e-007
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.050116693+du0n_5m    lu0=5.8285953e-009+dlu0n_5m
+ wu0=-8.4107344e-010+dwu0n_5m                        pu0=-1.8122755e-016+dpu0n_5m
+ ua=9.0069953e-010         lua=-1.2899035e-017       wua=-1.4476805e-017
+ pua=-5.0062859e-024       ub=1.4480571e-018         lub=-5.0489713e-025
+ wub=-4.4936086e-026       pub=-7.120939e-032        uc=5.1725205e-011
+ luc=-1.5620347e-017       wuc=-2.1354965e-017       puc=-1.8393064e-025
+ vsat=85493.073            lvsat=-0.0050233223+dlvsatn_5m
+ wvsat=-0.000102663        pvsat=3.6045258e-009+dpvsatn_5m
+ a0=1.2658359              la0=-7.7962093e-007       wa0=-4.9177663e-008
+ pa0=5.0062879e-014        ags=0.17611773            lags=1.413217e-008
+ wags=-8.8519779e-009      pags=9.0113045e-015       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.003166396         lketa=-3.9333051e-008     wketa=-5.3661222e-009
+ pketa=1.6185321e-014      dwg=0                     dwb=0
+ pclm=0.036963003          lpclm=1.7287952e-007      wpclm=-2.2220609e-008
+ ppclm=4.5056573e-014      pdiblc1=0                 pdiblc2=4.3943441e-005
+ lpdiblc2=6.1655804e-012   wpdiblc2=-1.9671064e-011  ppdiblc2=2.0025141e-017
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.005               pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=39                 beta0=42.8
+ agidl=9.6672168e-014      lagidl=3.2869013e-020     bgidl=7.5e+008
+ cgidl=0.5                 egidl=0.26                aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_5m
+ cgdo=cgon_5m              cgbo=0                    cgdl=cgln_5m
+ cgsl=cgln_5m              clc=1e-007                cle=0.6
+ cf=cfn_5m                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7                    noff=2.5
+ voffcv=-0.05              tvoff=0.0010281091        ltvoff=1.0834308e-009
+ wtvoff=-9.4581756e-010    ptvoff=-1.132624e-016     kt1=-0.34433738
+ lkt1=1.4729244e-008       wkt1=2.6393858e-009       pkt1=-2.0007481e-014
+ kt1l=0                    kt2=-0.046139253          lkt2=5.5622945e-010
+ wkt2=-1.1827519e-009      pkt2=2.550201e-015        ute=-1.6407978
+ lute=-9.1188876e-008      wute=1.7036532e-007       pute=1.1033854e-013
+ ua1=-3.4018846e-010       lua1=-1.4142376e-016      wua1=1.1439927e-015
+ pua1=7.8447508e-022       ub1=1.0903614e-018        lub1=5.3028132e-025
+ wub1=-1.7305198e-024      pub1=-1.0514903e-030      uc1=4.5897141e-011
+ luc1=5.1347173e-017       wuc1=-4.0749052e-017      puc1=-6.1435143e-024
+ prt=0                     at=102827.35              lat=-0.10351345
+ wat=-0.020239005          pat=2.7938177e-008        fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.00
+ noia=2e+41                noib=1e+22                noic=1e+6
+ lintnoi=1.0e-7            jss=4.865e-7              jsd=4.865e-7
+ jsws=2.498e-12            jswd=2.498e-12            jswgs=1e-012
+ jswgd=1e-012              njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.3                   bvd=9.3
+ xjbvs=1                   xjbvd=1                   jtsswgs=8.75e-010
+ jtsswgd=8.75e-010         njtsswg=39                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.702                 pbd=0.702
+ cjs=cjn_5m                cjd=cjn_5m                mjs=0.308
+ mjd=0.308                 pbsws=0.394               pbswd=0.394
+ cjsws=cjswn_5m            cjswd=cjswn_5m            mjsws=0.096
+ mjswd=0.096               pbswgs=0.574              pbswgd=0.574
+ cjswgs=cjswgn_5m          cjswgd=cjswgn_5m          mjswgs=0.238
+ mjswgd=0.238              tpb=1.4e-3                tcj=7.372e-4
+ tpbsw=1.6e-3              tcjsw=5.458e-4            tpbswg=4.40e-4
+ tcjswg=3.95e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   rshg=8.23
+ minr=1e-3
 
     9: type=n 
+ lmin=8.0e-07              lmax=1.2e-006-dxln_5m+dlmisn_5m
+ wmin=5e-007-dxwn_5m+dwmisn_5m                       wmax=1.2e-006-dxwn_5m+dwmisn_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.34612119+dvthn_5m+vthmisn_5m
+ lvth0=6.8911574e-008+dlvthn_5m                      wvth0=-1.4413557e-009+dwvthn_5m
+ pvth0=4.1596192e-015+dpvthn_5m                      k1=0.585
+ k2=0.045606941+dk2n_5m    lk2=1.141635e-008+dlk2n_5m
+ wk2=2.0183542e-009        pk2=-4.2982847e-015       k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00039070218
+ lcit=-1.0615053e-010      wcit=-1.8146634e-010      pcit=1.3986074e-016
+ voff=-0.072553929         lvoff=-2.9321672e-008     wvoff=-1.1217996e-008
+ pvoff=6.9327218e-015      nfactor=0.5               eta0=0.0012711571
+ weta0=8.8068986e-010      etab=-0.87985429          wetab=6.3543669e-007
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.055978321+du0n_5m    lu0=-1.3854209e-010+dlu0n_5m
+ wu0=-4.9226684e-009+dwu0n_5m                        pu0=3.9738361e-015+dpu0n_5m
+ ua=1.7932661e-009         lua=-9.2153179e-016       wua=-7.8757826e-016
+ pua=7.8201099e-022        ub=-8.926266e-020         lub=1.0600944e-024
+ wub=1.3144259e-024        pub=-1.4550399e-030       uc=7.1363069e-011
+ luc=-3.5611693e-017       wuc=-1.0122805e-017       puc=-1.161827e-023
+ vsat=89519.571            lvsat=-0.009122298+dlvsatn_5m
+ wvsat=0.0034381286        pvsat=1.678568e-022+dpvsatn_5m
+ a0=1.3144358              la0=-8.2909569e-007       wa0=1.3620278e-007
+ pa0=-1.3865441e-013       ags=0.061985747           lags=1.3031853e-007
+ wags=1.3620278e-007       pags=-1.3865444e-013      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.039862361         lketa=-1.9765592e-009     wketa=6.4132971e-009
+ pketa=4.1938724e-015      dwg=0                     dwb=0
+ pclm=-0.25196896          lpclm=4.6701225e-007      wpclm=1.3781167e-007
+ ppclm=-1.1785628e-013     pdiblc1=0                 pdiblc2=-0.0012659626
+ lpdiblc2=1.3396499e-009   wpdiblc2=-3.7060778e-010  ppdiblc2=3.7727872e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.005               pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=39                 beta0=42.8
+ agidl=1.2896e-013         bgidl=7.5e+008            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5m              cgdo=cgon_5m
+ cgbo=0                    cgdl=cgln_5m              cgsl=cgln_5m
+ clc=1e-007                cle=0.6                   cf=cfn_5m
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.007537322         ltvoff=-5.5429479e-009    wtvoff=-5.114421e-009
+ ptvoff=4.1303759e-015     kt1=-0.1863379            lkt1=-1.4611422e-007
+ wkt1=-1.0554189e-007      pkt1=9.0121057e-014       kt1l=0
+ kt2=-0.052424549          lkt2=6.9546615e-009       wkt2=8.6676564e-010
+ pkt2=4.6379216e-016       ute=-2.5570133            lute=8.4151851e-007
+ wute=7.1310357e-007       pute=-4.42169e-013        ua1=-8.3564028e-009
+ lua1=8.0190824e-015       wua1=7.0125313e-015       pua1=-5.1896972e-021
+ ub1=1.1901343e-017        lub1=-1.0475298e-023      wub1=-1.1127699e-023
+ pub1=8.5148379e-030       uc1=1.5607293e-010        luc1=-6.0811776e-017
+ wuc1=-1.1906513e-016      puc1=7.3582254e-023       prt=0
+ at=-23782.913             lat=0.025375798           wat=0.01803105
+ pat=-1.1020739e-008       fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.00                   noia=2e+41
+ noib=1e+22                noic=1e+6                 lintnoi=1.0e-7
+ jss=4.865e-7              jsd=4.865e-7              jsws=2.498e-12
+ jswd=2.498e-12            jswgs=1e-012              jswgd=1e-012
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.3                   bvd=9.3                   xjbvs=1
+ xjbvd=1                   jtsswgs=8.75e-010         jtsswgd=8.75e-010
+ njtsswg=39                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.702                 pbd=0.702                 cjs=cjn_5m
+ cjd=cjn_5m                mjs=0.308                 mjd=0.308
+ pbsws=0.394               pbswd=0.394               cjsws=cjswn_5m
+ cjswd=cjswn_5m            mjsws=0.096               mjswd=0.096
+ pbswgs=0.574              pbswgd=0.574              cjswgs=cjswgn_5m
+ cjswgd=cjswgn_5m          mjswgs=0.238              mjswgd=0.238
+ tpb=1.4e-3                tcj=7.372e-4              tpbsw=1.6e-3
+ tcjsw=5.458e-4            tpbswg=4.40e-4            tcjswg=3.95e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   rshg=8.23                 minr=1e-3
 
     10: type=n 
+ lmin=1e-005-dxln_5m+dlmisn_5m                       lmax=900.01e-6
+ wmin=2.2e-07              wmax=5e-007-dxwn_5m+dwmisn_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.40682143+dvthn_5m+vthmisn_5m
+ wvth0=-4.1892857e-010+dwvthn_5m                     k1=0.585
+ k2=0.058017857+dk2n_5m    wk2=-2.3041071e-009       k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0003875
+ wcit=-2.9325e-011         voff=-0.10111732          wvoff=1.5898339e-009
+ nfactor=0.5               eta0=0.002998             etab=0.3661
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.052902143+du0n_5m    wu0=-1.9773429e-009+dwu0n_5m
+ ua=8.0017857e-010         wua=3.5608929e-017        ub=1.5003964e-018
+ wub=-1.0510918e-025       uc=4.3870071e-011         wuc=-1.8178986e-017
+ vsat=85089.286            wvsat=0.00020946429       a0=1.1410714
+ wa0=-2.0946429e-008       ags=0.17054286            wags=-4.3568571e-009
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.019706            wketa=2.67444e-009
+ dwg=0                     dwb=0                     pclm=-0.045714286
+ wpclm=3.3514286e-008      pdiblc1=0                 pdiblc2=-6.4285714e-006
+ wpdiblc2=8.3785714e-012   pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.005               pscbe1=3.9e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=651.4                prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=39
+ beta0=42.8                agidl=1.0002e-013         bgidl=7.5e+008
+ cgidl=0.5                 egidl=0.26                aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_5m
+ cgdo=cgon_5m              cgbo=0                    cgdl=cgln_5m
+ cgsl=cgln_5m              clc=1e-007                cle=0.6
+ cf=cfn_5m                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7                    noff=2.5
+ voffcv=-0.05              tvoff=-0.0035257386       ltvoff=0
+ wtvoff=1.4213878e-009     ptvoff=0                  kt1=-0.38200427
+ wkt1=2.0576779e-008       kt1l=0                    kt2=-0.053906137
+ wkt2=3.0670004e-009       ute=-1.3805786            wute=4.4155071e-008
+ ua1=1.9682321e-009        wua1=3.9253607e-017       ub1=-1.8589929e-018
+ wub1=-3.0590164e-025      uc1=2.2120464e-011        wuc1=-2.6581437e-017
+ prt=0                     at=37602.632              wat=0.010494159
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.00                   noia=2e+41                noib=1e+22
+ noic=1e+6                 lintnoi=1.0e-7            jss=4.865e-7
+ jsd=4.865e-7              jsws=2.498e-12            jswd=2.498e-12
+ jswgs=1e-012              jswgd=1e-012              njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.3
+ bvd=9.3                   xjbvs=1                   xjbvd=1
+ jtsswgs=8.75e-010         jtsswgd=8.75e-010         njtsswg=39
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.702
+ pbd=0.702                 cjs=cjn_5m                cjd=cjn_5m
+ mjs=0.308                 mjd=0.308                 pbsws=0.394
+ pbswd=0.394               cjsws=cjswn_5m            cjswd=cjswn_5m
+ mjsws=0.096               mjswd=0.096               pbswgs=0.574
+ pbswgd=0.574              cjswgs=cjswgn_5m          cjswgd=cjswgn_5m
+ mjswgs=0.238              mjswgd=0.238              tpb=1.4e-3
+ tcj=7.372e-4              tpbsw=1.6e-3              tcjsw=5.458e-4
+ tpbswg=4.40e-4            tcjswg=3.95e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lvth0=0+dlvthn_5m         pvth0=0+dpvthn_5m         lu0=0+dlu0n_5m
+ pu0=0+dpu0n_5m            lk2=0+dlk2n_5m            lvsat=0+dlvsatn_5m
+ pvsat=0+dpvsatn_5m        rshg=8.23                 minr=1e-3
 
     11: type=n 
+ lmin=1.2e-006-dxln_5m+dlmisn_5m                     lmax=1e-005-dxln_5m+dlmisn_5m
+ wmin=2.2e-07              wmax=5e-007-dxwn_5m+dwmisn_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.40294196+dvthn_5m+vthmisn_5m
+ lvth0=3.808866e-008+dlvthn_5m                       wvth0=7.926319e-010+dwvthn_5m
+ pvth0=-1.1895101e-014+dpvthn_5m                     k1=0.585
+ k2=0.057895978+dk2n_5m    lk2=1.1966086e-009+dlk2n_5m
+ wk2=-2.1829511e-009       pk2=-1.1895101e-015       k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00040092322
+ lcit=-1.3178922e-010      wcit=-2.850114e-011       pcit=-8.088659e-018
+ voff=-0.09818927          lvoff=-2.8747609e-008     wvoff=8.0450043e-010
+ pvoff=7.7104043e-015      nfactor=0.5               eta0=0.002998
+ etab=0.3661               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.052332889+du0n_5m
+ lu0=5.5889328e-009+dlu0n_5m                         wu0=-1.9713335e-009+dwu0n_5m
+ pu0=-5.89997e-017+dpu0n_5m                          ua=7.8795348e-010
+ lua=1.2002593e-016        wua=4.3023679e-017        pua=-7.2798016e-023
+ ub=1.5824381e-018         lub=-8.0548507e-025       wub=-1.134704e-025
+ pub=8.2090459e-032        uc=4.5746731e-011         luc=-1.8425044e-017
+ wuc=-1.8305944e-017       puc=1.2464646e-024        vsat=84538.971
+ lvsat=0.005402992+dlvsatn_5m                        wvsat=0.00038392899
+ pvsat=-1.7128945e-009+dpvsatn_5m                    a0=1.1914756
+ la0=-4.9486853e-007       wa0=-1.1253941e-008       pa0=-9.5160844e-014
+ ags=0.16449105            lags=5.9416687e-008       wags=-2.9223696e-009
+ pags=-1.4083799e-014      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.018687516
+ lketa=-9.9994719e-009     wketa=2.5496492e-009      pketa=1.2251959e-015
+ dwg=0                     dwb=0                     pclm=-0.099403045
+ lpclm=5.2711624e-007      wpclm=4.7326076e-008      ppclm=-1.3560416e-013
+ pdiblc1=0                 pdiblc2=-1.5807062e-005   lpdiblc2=9.2078018e-011
+ wpdiblc2=1.0801692e-011   ppdiblc2=-2.3790202e-017  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.005
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=39                 beta0=42.8                agidl=9.6672168e-014
+ lagidl=3.2869013e-020     bgidl=7.5e+008            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5m              cgdo=cgon_5m
+ cgbo=0                    cgdl=cgln_5m              cgsl=cgln_5m
+ clc=1e-007                cle=0.6                   cf=cfn_5m
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=-0.0037721693       ltvoff=2.4194564e-009     wtvoff=1.5023244e-009
+ ptvoff=-7.9463548e-016    kt1=-0.37917022           lkt1=-2.7824612e-008
+ wkt1=2.0404138e-008       pkt1=1.6949852e-015       kt1l=0
+ kt2=-0.055216051          lkt2=1.2860734e-008       wkt2=3.4464154e-009
+ pkt2=-3.7250964e-015      ute=-1.4224232            lute=4.1083021e-007
+ wute=5.8994264e-008       pute=-1.4569119e-013      ua1=1.5897437e-009
+ lua1=3.7159997e-015       wua1=1.5972732e-016       pua1=-1.1828109e-021
+ ub1=-1.3349753e-018       lub1=-5.1448042e-024      wub1=-4.9359805e-025
+ pub1=1.8428034e-030       uc1=2.9189723e-011        luc1=-6.9405977e-017
+ wuc1=-3.2228268e-017      puc1=5.5440592e-023       prt=0
+ at=39487.167              lat=-0.018502363          wat=0.012064486
+ pat=-1.5417475e-008       fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.00                   noia=2e+41
+ noib=1e+22                noic=1e+6                 lintnoi=1.0e-7
+ jss=4.865e-7              jsd=4.865e-7              jsws=2.498e-12
+ jswd=2.498e-12            jswgs=1e-012              jswgd=1e-012
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.3                   bvd=9.3                   xjbvs=1
+ xjbvd=1                   jtsswgs=8.75e-010         jtsswgd=8.75e-010
+ njtsswg=39                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.702                 pbd=0.702                 cjs=cjn_5m
+ cjd=cjn_5m                mjs=0.308                 mjd=0.308
+ pbsws=0.394               pbswd=0.394               cjsws=cjswn_5m
+ cjswd=cjswn_5m            mjsws=0.096               mjswd=0.096
+ pbswgs=0.574              pbswgd=0.574              cjswgs=cjswgn_5m
+ cjswgd=cjswgn_5m          mjswgs=0.238              mjswgd=0.238
+ tpb=1.4e-3                tcj=7.372e-4              tpbsw=1.6e-3
+ tcjsw=5.458e-4            tpbswg=4.40e-4            tcjswg=3.95e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   rshg=8.23                 minr=1e-3
 
     12: type=n 
+ lmin=8.0e-07              lmax=1.2e-006-dxln_5m+dlmisn_5m
+ wmin=2.2e-07              wmax=5e-007-dxwn_5m+dwmisn_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_5m+toxmisn_5m
+ toxm=toxn_5m+toxmisn_5m   dtox=8.5e-010             epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ wwc=0                     xl=-3e-08+dxln_5m+dlmisn_5m
+ xw=1e-08+dxwn_5m+dwmisn_5m                          dlc=2.3e-008
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.35576839+dvthn_5m+vthmisn_5m
+ lvth0=8.6111348e-008+dlvthn_5m                      wvth0=-6.3614304e-009+dwvthn_5m
+ pvth0=-4.6122653e-015+dpvthn_5m                     k1=0.585
+ k2=0.065019676+dk2n_5m    lk2=-6.0553156e-009+dlk2n_5m
+ wk2=-7.8821404e-009       pk2=4.6122647e-015        k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00027149898
+ lcit=-3.5333738e-014      wcit=-1.206727e-010       pcit=8.5741993e-017
+ voff=-0.0982875           lvoff=-2.8647611e-008     wvoff=1.906125e-009
+ pvoff=6.5889505e-015      nfactor=0.5               eta0=0.002998
+ etab=0.3661               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.051739121+du0n_5m
+ lu0=6.1933888e-009+dlu0n_5m                         wu0=-2.7606765e-009+dwu0n_5m
+ pu0=7.445514e-016+dpu0n_5m                          ua=-1.4060446e-010
+ lua=1.0652979e-015        wua=1.9869573e-016        pua=-2.3127216e-022
+ ub=3.5173717e-018         lub=-2.7752474e-024       wub=-5.2495757e-025
+ pub=5.009844e-031         uc=5.9113122e-011         luc=-3.2032029e-017
+ wuc=-3.8753313e-018       puc=-1.3443899e-023       vsat=103725.22
+ lvsat=-0.014128608+dlvsatn_5m                       wvsat=-0.0038067516
+ pvsat=2.5532183e-009+dpvsatn_5m                     a0=2.4848664
+ la0=-1.8115403e-006       wa0=-4.607168e-007        pa0=3.6239234e-013
+ ags=0.4380536             lags=-2.1906999e-007      wags=-5.5591828e-008
+ pags=3.9533709e-014       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.020920158
+ lketa=-7.7266429e-009     wketa=-3.2472263e-009     pketa=7.1264151e-015
+ dwg=0                     dwb=0                     pclm=0.35573872
+ lpclm=6.378192e-008       wpclm=-1.7211925e-007     ppclm=8.7791186e-014
+ pdiblc1=0                 pdiblc2=-0.0025290739     lpdiblc2=2.6505837e-009
+ wpdiblc2=2.73579e-010     ppdiblc2=-2.912975e-016   pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.005
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=39                 beta0=42.8                agidl=1.2896e-013
+ bgidl=7.5e+008            cgidl=0.5                 egidl=0.26
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_5m              cgdo=cgon_5m              cgbo=0
+ cgdl=cgln_5m              cgsl=cgln_5m              clc=1e-007
+ cle=0.6                   cf=cfn_5m                 ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7
+ noff=2.5                  voffcv=-0.05              tvoff=-0.0018231297
+ ltvoff=4.3533412e-010     wtvoff=-3.4059063e-010    ptvoff=1.081452e-015
+ kt1=-0.45462979           lkt1=4.8993223e-008       wkt1=3.1286972e-008
+ pkt1=-9.3837395e-015      kt1l=0                    kt2=-0.047404212
+ lkt2=4.9082818e-009       wkt2=-1.6936064e-009      pkt2=1.5074458e-015
+ ute=-0.73899143           lute=-2.849033e-007       wute=-2.1408758e-007
+ pute=1.3230613e-013       ua1=1.1432048e-008        lua1=-6.3034662e-015
+ wua1=-3.0795787e-015      pua1=2.1148026e-021       ub1=-1.9213408e-017
+ lub1=1.305544e-023        wub1=4.7408239e-024       pub1=-3.4858382e-030
+ uc1=-1.8833036e-010       luc1=1.5202946e-016       wuc1=5.6580543e-017
+ puc1=-3.4966778e-023      prt=0                     at=22327.093
+ lat=-0.0010334075         wat=-0.0054850532         pat=2.4479557e-009
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.00                   noia=2e+41                noib=1e+22
+ noic=1e+6                 lintnoi=1.0e-7            jss=4.865e-7
+ jsd=4.865e-7              jsws=2.498e-12            jswd=2.498e-12
+ jswgs=1e-012              jswgd=1e-012              njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.3
+ bvd=9.3                   xjbvs=1                   xjbvd=1
+ jtsswgs=8.75e-010         jtsswgd=8.75e-010         njtsswg=39
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.702
+ pbd=0.702                 cjs=cjn_5m                cjd=cjn_5m
+ mjs=0.308                 mjd=0.308                 pbsws=0.394
+ pbswd=0.394               cjsws=cjswn_5m            cjswd=cjswn_5m
+ mjsws=0.096               mjswd=0.096               pbswgs=0.574
+ pbswgd=0.574              cjswgs=cjswgn_5m          cjswgd=cjswgn_5m
+ mjswgs=0.238              mjswgd=0.238              tpb=1.4e-3
+ tcj=7.372e-4              tpbsw=1.6e-3              tcjsw=5.458e-4
+ tpbswg=4.40e-4            tcjswg=3.95e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ rshg=8.23                 minr=1e-3
 
     } 
ends mench5_mac
// 
model mench5 bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_5m       lmax=900.01e-6            wmin=1e-005-dxwn_5m
+ wmax=900.01e-6            version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.41+dvthn_5m        k1=0.585                  k2=0.05255+dk2n_5m
+ k3=-2.011                 k3b=0.41625               w0=0
+ dvt0=3.6                  dvt1=0.21214              dvt2=0.025
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.296               voffl=0
+ dvtp0=1e-006              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=5.0535e-008          xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00016               voff=-0.094245            nfactor=0.5
+ eta0=0.001                etab=-0.3557              ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.056568+du0n_5m       ua=7.15e-010              ub=2.0138e-018
+ uc=6.5388e-011            vsat=85000                a0=1.4
+ ags=0.189                 a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.018556
+ dwg=0                     dwb=0                     pclm=0.099988
+ pdiblc1=0                 pdiblc2=0.00011           pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.005
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=39                 beta0=42.8                agidl=1e-014
+ bgidl=7.5e+008            cgidl=0.5                 egidl=0.26
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_5m              cgdo=cgon_5m              cgbo=0
+ cgdl=cgln_5m              cgsl=cgln_5m              clc=1e-007
+ cle=0.6                   cf=cfn_5m                 ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7
+ noff=2.5                  voffcv=-0.05              tvoff=0.0022215959
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ kt1=-0.31561              kt1l=0                    kt2=-0.043125392
+ ute=-1.6694               ua1=1.2666e-009           ub1=-1.6092e-018
+ uc1=2.0802e-011           prt=0                     at=63159.41
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.00                   noia=2e+41                noib=1e+22
+ noic=1e+6                 lintnoi=1.0e-7            jss=4.865e-7
+ jsd=4.865e-7              jsws=2.498e-12            jswd=2.498e-12
+ jswgs=1e-012              jswgd=1e-012              njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.3
+ bvd=9.3                   xjbvs=1                   xjbvd=1
+ jtsswgs=8.75e-010         jtsswgd=8.75e-010         njtsswg=39
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.702
+ pbd=0.702                 cjs=cjn_5m                cjd=cjn_5m
+ mjs=0.308                 mjd=0.308                 pbsws=0.394
+ pbswd=0.394               cjsws=cjswn_5m            cjswd=cjswn_5m
+ mjsws=0.096               mjswd=0.096               pbswgs=0.574
+ pbswgd=0.574              cjswgs=cjswgn_5m          cjswgd=cjswgn_5m
+ mjswgs=0.238              mjswgd=0.238              tpb=1.4e-3
+ tcj=7.372e-4              tpbsw=1.6e-3              tcjsw=5.458e-4
+ tpbswg=4.40e-4            tcjswg=3.95e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lvth0=0+dlvthn_5m         wvth0=0+dwvthn_5m         pvth0=0+dpvthn_5m
+ wu0=0+dwu0n_5m            lu0=0+dlu0n_5m            pu0=0+dpu0n_5m
+ lk2=0+dlk2n_5m            lvsat=0+dlvsatn_5m        pvsat=0+dpvsatn_5m
+ rshg=8.23                 minr=1e-3
 
     2: type=n 
+ lmin=1.2e-006-dxln_5m     lmax=1e-005-dxln_5m       wmin=1e-005-dxwn_5m
+ wmax=900.01e-6            version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.40953727+dvthn_5m  lvth0=4.5430564e-009+dlvthn_5m
+ k1=0.585                  k2=0.051977375+dk2n_5m    lk2=5.6220323e-009+dlk2n_5m
+ k3=-2.011                 k3b=0.41625               w0=0
+ dvt0=3.6                  dvt1=0.21214              dvt2=0.025
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.296               voffl=0
+ dvtp0=1e-006              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=5.0535e-008          xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00016115682         lcit=-1.1357641e-011      voff=-0.094240373
+ lvoff=-4.5430564e-011     nfactor=0.5               eta0=0.001
+ etab=-0.3557              ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.055823935+du0n_5m
+ lu0=7.3052346e-009+dlu0n_5m                         ua=7.2113114e-010
+ lua=-6.0195497e-017       ub=2.0291394e-018         lub=-1.5060232e-025
+ uc=6.6919049e-011         luc=-1.5031838e-017       vsat=85335.477
+ lvsat=-0.0032937159+dlvsatn_5m                      a0=1.4925455
+ la0=-9.0861126e-007       ags=0.19929568            lags=-1.01083e-007
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.018606784         lketa=4.9860044e-010
+ dwg=0                     dwb=0                     pclm=0.091888885
+ lpclm=7.9517116e-008      pdiblc1=0                 pdiblc2=0.00011115682
+ lpdiblc2=-1.1357641e-011  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.005               pscbe1=3.9e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=651.4                prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=39
+ beta0=42.8                agidl=1e-014              bgidl=7.5e+008
+ cgidl=0.5                 egidl=0.26                aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_5m
+ cgdo=cgon_5m              cgbo=0                    cgdl=cgln_5m
+ cgsl=cgln_5m              clc=1e-007                cle=0.6
+ cf=cfn_5m                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7                    noff=2.5
+ voffcv=-0.05              tvoff=0.0021963391        ltvoff=2.4797092e-010
+ wtvoff=0                  ptvoff=0                  kt1=-0.31341552
+ lkt1=-2.1545445e-008      kt1l=0                    kt2=-0.04309856
+ lkt2=-2.6344162e-010      ute=-1.6889965            lute=1.9239844e-007
+ ua1=1.0941184e-009        lua1=1.6934242e-015       ub1=-1.4506234e-018
+ lub1=-1.5569054e-024      uc1=1.9272224e-011        luc1=1.501934e-017
+ prt=0                     at=70986.374              lat=-0.076845135
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.00                   noia=2e+41                noib=1e+22
+ noic=1e+6                 lintnoi=1.0e-7            jss=4.865e-7
+ jsd=4.865e-7              jsws=2.498e-12            jswd=2.498e-12
+ jswgs=1e-012              jswgd=1e-012              njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.3
+ bvd=9.3                   xjbvs=1                   xjbvd=1
+ jtsswgs=8.75e-010         jtsswgd=8.75e-010         njtsswg=39
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.702
+ pbd=0.702                 cjs=cjn_5m                cjd=cjn_5m
+ mjs=0.308                 mjd=0.308                 pbsws=0.394
+ pbswd=0.394               cjsws=cjswn_5m            cjswd=cjswn_5m
+ mjsws=0.096               mjswd=0.096               pbswgs=0.574
+ pbswgd=0.574              cjswgs=cjswgn_5m          cjswgd=cjswgn_5m
+ mjswgs=0.238              mjswgd=0.238              tpb=1.4e-3
+ tcj=7.372e-4              tpbsw=1.6e-3              tcjsw=5.458e-4
+ tpbswg=4.40e-4            tcjswg=3.95e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthn_5m         pvth0=0+dpvthn_5m         wu0=0+dwu0n_5m
+ pu0=0+dpu0n_5m            pvsat=0+dpvsatn_5m        rshg=8.23
+ minr=1e-3
 
     3: type=n 
+ lmin=8.0e-07              lmax=1.2e-006-dxln_5m     wmin=1e-005-dxwn_5m
+ wmax=900.01e-6            version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.36455999+dvthn_5m  lvth0=5.0329936e-008+dlvthn_5m
+ k1=0.585                  k2=0.04514+dk2n_5m        lk2=1.258248e-008+dlk2n_5m
+ k3=-2.011                 k3b=0.41625               w0=0
+ dvt0=3.6                  dvt1=0.21214              dvt2=0.025
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.296               voffl=0
+ dvtp0=1e-006              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=5.0535e-008          xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=8.82e-005             lcit=6.29124e-011         voff=-0.10090532
+ lvoff=6.7394893e-009      nfactor=0.5               eta0=0.001
+ etab=-0.3557              ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.054534945+du0n_5m
+ lu0=8.617426e-009+dlu0n_5m                          ua=2.21675e-010
+ lua=4.4825085e-016        ub=3.1899695e-018         lub=-1.3323274e-024
+ uc=8.8628905e-011         luc=-3.7132471e-017       vsat=97550
+ lvsat=-0.0157281+dlvsatn_5m                         a0=1.5579001
+ la0=-9.751423e-007        ags=0.1                   a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.0097627601        lketa=-8.5046162e-009     dwg=0
+ dwb=0                     pclm=-0.21625             lpclm=3.932025e-007
+ pdiblc1=0                 pdiblc2=-0.00098149997    lpdiblc2=1.100967e-009
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.005               pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=39                 beta0=42.8
+ agidl=1e-014              bgidl=7.5e+008            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5m              cgdo=cgon_5m
+ cgbo=0                    cgdl=cgln_5m              cgsl=cgln_5m
+ clc=1e-007                cle=0.6                   cf=cfn_5m
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.0032887901        ltvoff=-8.6414412e-010    wtvoff=0
+ ptvoff=0                  kt1=-0.27953423           lkt1=-5.6036594e-008
+ kt1l=0                    kt2=-0.054796089          lkt2=1.1644643e-008
+ ute=-1.5                  ua1=1.7431528e-009        lua1=1.0327072e-015
+ ub1=-1.7494075e-018       lub1=-1.2527432e-024      uc1=7.5149255e-011
+ luc1=-4.1863478e-017      prt=0                     at=-36126.166
+ lat=0.032195431           fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.00                   noia=2e+41
+ noib=1e+22                noic=1e+6                 lintnoi=1.0e-7
+ jss=4.865e-7              jsd=4.865e-7              jsws=2.498e-12
+ jswd=2.498e-12            jswgs=1e-012              jswgd=1e-012
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.3                   bvd=9.3                   xjbvs=1
+ xjbvd=1                   jtsswgs=8.75e-010         jtsswgd=8.75e-010
+ njtsswg=39                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.702                 pbd=0.702                 cjs=cjn_5m
+ cjd=cjn_5m                mjs=0.308                 mjd=0.308
+ pbsws=0.394               pbswd=0.394               cjsws=cjswn_5m
+ cjswd=cjswn_5m            mjsws=0.096               mjswd=0.096
+ pbswgs=0.574              pbswgd=0.574              cjswgs=cjswgn_5m
+ cjswgd=cjswgn_5m          mjswgs=0.238              mjswgd=0.238
+ tpb=1.4e-3                tcj=7.372e-4              tpbsw=1.6e-3
+ tcjsw=5.458e-4            tpbswg=4.40e-4            tcjswg=3.95e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wvth0=0+dwvthn_5m         pvth0=0+dpvthn_5m
+ wu0=0+dwu0n_5m            pu0=0+dpu0n_5m            pvsat=0+dpvsatn_5m
+ rshg=8.23                 minr=1e-3
 
     4: type=n 
+ lmin=1e-005-dxln_5m       lmax=900.01e-6            wmin=1.2e-006-dxwn_5m
+ wmax=1e-005-dxwn_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.409725+dvthn_5m    wvth0=2.75275e-009+dwvthn_5m
+ k1=0.585                  k2=0.052488125+dk2n_5m    wk2=6.1936875e-010
+ k3=-2.011                 k3b=0.41625               w0=0
+ dvt0=3.6                  dvt1=0.21214              dvt2=0.025
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.296               voffl=0
+ dvtp0=1e-006              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=5.0535e-008          xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.000129475           wcit=3.0555525e-010       voff=-0.093453688
+ wvoff=-7.9210381e-009     nfactor=0.5               eta0=0.0008626375
+ weta0=1.3749986e-009      etab=-0.3558375           wetab=1.376375e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.0574711+du0n_5m      wu0=-9.040031e-009+dwu0n_5m
+ ua=6.9135e-010            wua=2.367365e-016         ub=2.1045913e-018
+ wub=-9.0882041e-025       uc=6.9914225e-011         wuc=-4.5307512e-017
+ vsat=84972.5              wvsat=0.000275275         a0=1.434375
+ wa0=-3.4409375e-007       ags=0.191475              wags=-2.477475e-008
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.019698763         wketa=1.1439053e-008
+ dwg=0                     dwb=0                     pclm=0.10823635
+ wpclm=-8.2565984e-008     pdiblc1=0                 pdiblc2=0.000121
+ wpdiblc2=-1.1011e-010     pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.005               pscbe1=3.9e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=651.4                prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=39
+ beta0=42.8                agidl=-2.37775e-015       wagidl=1.2390128e-019
+ bgidl=7.5e+008            cgidl=0.5                 egidl=0.26
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_5m              cgdo=cgon_5m              cgbo=0
+ cgdl=cgln_5m              cgsl=cgln_5m              clc=1e-007
+ cle=0.6                   cf=cfn_5m                 ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7
+ noff=2.5                  voffcv=-0.05              tvoff=0.0024793172
+ ltvoff=0                  wtvoff=-2.5797902e-009    ptvoff=0
+ kt1=-0.31193463           wkt1=-3.6790504e-008      kt1l=0
+ kt2=-0.042613889          wkt2=-5.1201425e-009      ute=-1.6926925
+ wute=2.3315793e-007       ua1=1.3504351e-009        wua1=-8.391896e-016
+ ub1=-1.778996e-018        wub1=1.699658e-024        uc1=2.1333988e-011
+ wuc1=-5.3251949e-018      prt=0                     at=61131.286
+ wat=0.020301526           fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.00                   noia=2e+41
+ noib=1e+22                noic=1e+6                 lintnoi=1.0e-7
+ jss=4.865e-7              jsd=4.865e-7              jsws=2.498e-12
+ jswd=2.498e-12            jswgs=1e-012              jswgd=1e-012
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.3                   bvd=9.3                   xjbvs=1
+ xjbvd=1                   jtsswgs=8.75e-010         jtsswgd=8.75e-010
+ njtsswg=39                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.702                 pbd=0.702                 cjs=cjn_5m
+ cjd=cjn_5m                mjs=0.308                 mjd=0.308
+ pbsws=0.394               pbswd=0.394               cjsws=cjswn_5m
+ cjswd=cjswn_5m            mjsws=0.096               mjswd=0.096
+ pbswgs=0.574              pbswgd=0.574              cjswgs=cjswgn_5m
+ cjswgd=cjswgn_5m          mjswgs=0.238              mjswgd=0.238
+ tpb=1.4e-3                tcj=7.372e-4              tpbsw=1.6e-3
+ tcjsw=5.458e-4            tpbswg=4.40e-4            tcjswg=3.95e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthn_5m         pvth0=0+dpvthn_5m
+ lu0=0+dlu0n_5m            pu0=0+dpu0n_5m            lk2=0+dlk2n_5m
+ lvsat=0+dlvsatn_5m        pvsat=0+dpvsatn_5m        rshg=8.23
+ minr=1e-3
 
     5: type=n 
+ lmin=1.2e-006-dxln_5m     lmax=1e-005-dxln_5m       wmin=1.2e-006-dxwn_5m
+ wmax=1e-005-dxwn_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.40926227+dvthn_5m  lvth0=4.5430564e-009+dlvthn_5m
+ wvth0=2.75275e-009+dwvthn_5m                        pvth0=1.9076232e-029+dpvthn_5m
+ k1=0.585                  k2=0.051868577+dk2n_5m    lk2=6.0827264e-009+dlk2n_5m
+ wk2=1.0890722e-009        pk2=-4.6115485e-015       k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00012869126
+ lcit=7.6948017e-012       wcit=3.2498028e-010       pcit=-1.9071495e-016
+ voff=-0.093527955         lvoff=7.2916055e-010      wvoff=-7.1312992e-009
+ pvoff=-7.753657e-015      nfactor=0.5               eta0=0.0008626375
+ weta0=1.3749986e-009      etab=-0.3558375           wetab=1.376375e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.056704257+du0n_5m    lu0=7.5288666e-009+dlu0n_5m
+ wu0=-8.8120257e-009+dwu0n_5m                        pu0=-2.2385558e-015+dpu0n_5m
+ ua=6.9808557e-010         lua=-6.6129864e-017       wua=2.3068608e-016
+ pua=5.9403017e-023        ub=2.1141446e-018         lub=-9.3794806e-026
+ wub=-8.5090198e-025       pub=-5.686432e-031        uc=7.1434903e-011
+ luc=-1.4930017e-017       wuc=-4.52037e-017         puc=-1.0192307e-024
+ vsat=85325.474            lvsat=-0.0034655002+dlvsatn_5m
+ wvsat=0.00010013128       pvsat=1.719561e-009+dpvsatn_5m
+ a0=1.5293064              la0=-9.320364e-007        wa0=-3.6797698e-007
+ pa0=2.344856e-013         ags=0.20348856            lags=-1.179491e-007
+ wags=-4.197068e-008       pags=1.6882964e-013       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.020120051         lketa=4.1362115e-009      wketa=1.5147801e-008
+ pketa=-3.6412486e-014     dwg=0                     dwb=0
+ pclm=0.10196626           lpclm=6.155972e-008       wpclm=-1.0087455e-007
+ ppclm=1.7975353e-013      pdiblc1=0                 pdiblc2=0.00012263401
+ lpdiblc2=-1.6042668e-011  wpdiblc2=-1.1488665e-010  ppdiblc2=4.6897122e-017
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.005               pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=39                 beta0=42.8
+ agidl=-1.9174231e-015     lagidl=-4.5194893e-021    wagidl=1.1929341e-019
+ pagidl=4.5240088e-026     bgidl=7.5e+008            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5m              cgdo=cgon_5m
+ cgbo=0                    cgdl=cgln_5m              cgsl=cgln_5m
+ clc=1e-007                cle=0.6                   cf=cfn_5m
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00246445          ltvoff=1.4596592e-010     wtvoff=-2.68379e-009
+ ptvoff=1.0210701e-015     kt1=-0.30946369           lkt1=-2.4259637e-008
+ wkt1=-3.9557775e-008      pkt1=2.7169064e-014       kt1l=0
+ kt2=-0.042546061          lkt2=-6.6594196e-010      wkt2=-5.5305141e-009
+ pkt2=4.0290284e-015       ute=-1.7149835            lute=2.1885322e-007
+ wute=2.6013006e-007       pute=-2.648124e-013       ua1=1.1613365e-009
+ lua1=1.8565708e-015       wua1=-6.7285243e-016      pua1=-1.6330984e-021
+ ub1=-1.6033588e-018       lub1=-1.7244061e-024      wub1=1.5288817e-024
+ pub1=1.6766815e-030       uc1=2.0241872e-011        luc1=1.0722389e-017
+ wuc1=-9.7061762e-018      puc1=4.3012474e-023       prt=0
+ at=68908.128              lat=-0.076353036          wat=0.020803249
+ pat=-4.9259189e-009       fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.00                   noia=2e+41
+ noib=1e+22                noic=1e+6                 lintnoi=1.0e-7
+ jss=4.865e-7              jsd=4.865e-7              jsws=2.498e-12
+ jswd=2.498e-12            jswgs=1e-012              jswgd=1e-012
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.3                   bvd=9.3                   xjbvs=1
+ xjbvd=1                   jtsswgs=8.75e-010         jtsswgd=8.75e-010
+ njtsswg=39                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.702                 pbd=0.702                 cjs=cjn_5m
+ cjd=cjn_5m                mjs=0.308                 mjd=0.308
+ pbsws=0.394               pbswd=0.394               cjsws=cjswn_5m
+ cjswd=cjswn_5m            mjsws=0.096               mjswd=0.096
+ pbswgs=0.574              pbswgd=0.574              cjswgs=cjswgn_5m
+ cjswgd=cjswgn_5m          mjswgs=0.238              mjswgd=0.238
+ tpb=1.4e-3                tcj=7.372e-4              tpbsw=1.6e-3
+ tcjsw=5.458e-4            tpbswg=4.40e-4            tcjswg=3.95e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   rshg=8.23                 minr=1e-3
 
     6: type=n 
+ lmin=8.0e-07              lmax=1.2e-006-dxln_5m     wmin=1.2e-006-dxwn_5m
+ wmax=1e-005-dxwn_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.36725911+dvthn_5m  lvth0=4.7302277e-008+dlvthn_5m
+ wvth0=-2.7018241e-008+dwvthn_5m                     pvth0=3.0306869e-014+dpvthn_5m
+ k1=0.585                  k2=0.044846437+dk2n_5m    lk2=1.3231264e-008+dlk2n_5m
+ wk2=2.9385641e-009        pk2=-6.4943313e-015       k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=6.7227125e-005
+ lcit=7.0265287e-011       wcit=2.0993848e-010       pcit=-7.3602396e-017
+ voff=-0.10352887          lvoff=1.091009e-008       wvoff=2.626168e-008
+ pvoff=-4.174771e-014      nfactor=0.5               eta0=0.0008626375
+ weta0=1.3749986e-009      etab=-0.3558375           wetab=1.376375e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.054895875+du0n_5m    lu0=9.3697993e-009+dlu0n_5m
+ wu0=-3.6129087e-009+dwu0n_5m                        pu0=-7.531257e-015+dpu0n_5m
+ ua=9.5078754e-011         lua=5.4773108e-016        wua=1.2672284e-015
+ pua=-9.9579708e-022       ub=3.4914973e-018         lub=-1.4959399e-024
+ wub=-3.0182937e-024       pub=1.6377615e-030        uc=9.2153276e-011
+ luc=-3.602132e-017        wuc=-3.5278955e-017       puc=-1.1122621e-023
+ vsat=98263.488            lvsat=-0.016636398+dlvsatn_5m
+ wvsat=-0.0071420099       pvsat=9.0920607e-009+dpvsatn_5m
+ a0=1.5758989              la0=-9.7946753e-007       wa0=-1.8016748e-007
+ pa0=4.3295514e-014        ags=0.089749372           lags=-2.1626116e-009
+ wags=1.0260879e-007       pags=2.1647742e-014       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.0063528488        lketa=-9.8788004e-009     wketa=-3.4133212e-008
+ pketa=1.3755584e-014      dwg=0                     dwb=0
+ pclm=-0.22699906          lpclm=3.9644642e-007      wpclm=1.0759809e-007
+ ppclm=-3.2471624e-014     pdiblc1=0                 pdiblc2=-0.00090027184
+ lpdiblc2=1.0252755e-009   wpdiblc2=-8.1309357e-010  ppdiblc2=7.5767177e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.005               pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=39                 beta0=42.8
+ agidl=-6.357e-015         wagidl=1.6373357e-019     bgidl=7.5e+008
+ cgidl=0.5                 egidl=0.26                aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_5m
+ cgdo=cgon_5m              cgbo=0                    cgdl=cgln_5m
+ cgsl=cgln_5m              clc=1e-007                cle=0.6
+ cf=cfn_5m                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7                    noff=2.5
+ voffcv=-0.05              tvoff=0.0032858011        ltvoff=-6.901695e-010
+ wtvoff=2.99193e-011       ptvoff=-1.741486e-015     kt1=-0.28035533
+ lkt1=-5.3891949e-008      wkt1=8.2191967e-009       pkt1=-2.1467892e-014
+ kt1l=0                    kt2=-0.055220672          lkt2=1.2236812e-008
+ wkt2=4.2500738e-009       pkt2=-5.9276101e-015      ute=-1.4356952
+ lute=-6.5462318e-008      wute=-6.4369136e-007      pute=6.5527781e-013
+ ua1=2.3349631e-009        lua1=6.6181892e-016       wua1=-5.9240214e-015
+ pua1=3.7125917e-021       ub1=-2.3618744e-018       lub1=-9.5223717e-025
+ wub1=6.1307938e-024       pub1=-3.008065e-030       uc1=7.7552379e-011
+ luc1=-4.7619707e-017      wuc1=-2.4055269e-017      puc1=5.7619851e-023
+ prt=0                     at=-39872.346             lat=0.034385487
+ wat=0.037499264           pat=-2.1922463e-008       fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.00
+ noia=2e+41                noib=1e+22                noic=1e+6
+ lintnoi=1.0e-7            jss=4.865e-7              jsd=4.865e-7
+ jsws=2.498e-12            jswd=2.498e-12            jswgs=1e-012
+ jswgd=1e-012              njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.3                   bvd=9.3
+ xjbvs=1                   xjbvd=1                   jtsswgs=8.75e-010
+ jtsswgd=8.75e-010         njtsswg=39                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.702                 pbd=0.702
+ cjs=cjn_5m                cjd=cjn_5m                mjs=0.308
+ mjd=0.308                 pbsws=0.394               pbswd=0.394
+ cjsws=cjswn_5m            cjswd=cjswn_5m            mjsws=0.096
+ mjswd=0.096               pbswgs=0.574              pbswgd=0.574
+ cjswgs=cjswgn_5m          cjswgd=cjswgn_5m          mjswgs=0.238
+ mjswgd=0.238              tpb=1.4e-3                tcj=7.372e-4
+ tpbsw=1.6e-3              tcjsw=5.458e-4            tpbswg=4.40e-4
+ tcjswg=3.95e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   rshg=8.23
+ minr=1e-3
 
     7: type=n 
+ lmin=1e-005-dxln_5m       lmax=900.01e-6            wmin=5e-007-dxwn_5m
+ wmax=1.2e-006-dxwn_5m     version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.41637143+dvthn_5m  wvth0=-5.2894286e-009+dwvthn_5m
+ k1=0.585                  k2=0.052635714+dk2n_5m    wk2=4.4078571e-010
+ k3=-2.011                 k3b=0.41625               w0=0
+ dvt0=3.6                  dvt1=0.21214              dvt2=0.025
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.296               voffl=0
+ dvtp0=1e-006              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=5.0535e-008          xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00041988571         wcit=-4.5841714e-011      voff=-0.10145714
+ wvoff=1.7631429e-009      nfactor=0.5               eta0=0.0012711571
+ weta0=8.8068986e-010      etab=-0.87985429          wetab=6.3543669e-007
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.050710357+du0n_5m    wu0=-8.5953214e-010+dwu0n_5m
+ ua=8.9938571e-010         wua=-1.4986714e-017       ub=1.3966314e-018
+ wub=-5.2189029e-026       uc=5.0134214e-011         wuc=-2.1373699e-017
+ vsat=84981.429            wvsat=0.00026447143       a0=1.1864286
+ wa0=-4.4078571e-008       ags=0.17755714            wags=-7.9341429e-009
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.0071726143        wketa=-3.7175867e-009
+ dwg=0                     dwb=0                     pclm=0.054571429
+ wpclm=-1.7631429e-008     pdiblc1=0                 pdiblc2=4.4571429e-005
+ wpdiblc2=-1.7631429e-011  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.005               pscbe1=3.9e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=651.4                prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=39
+ beta0=42.8                agidl=1.0002e-013         bgidl=7.5e+008
+ cgidl=0.5                 egidl=0.26                aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_5m
+ cgdo=cgon_5m              cgbo=0                    cgdl=cgln_5m
+ cgsl=cgln_5m              clc=1e-007                cle=0.6
+ cf=cfn_5m                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7                    noff=2.5
+ voffcv=-0.05              tvoff=0.0011384606        ltvoff=0
+ wtvoff=-9.5735376e-010    ptvoff=0                  kt1=-0.34283715
+ wkt1=6.0154908e-010       kt1l=0                    kt2=-0.046082598
+ wkt2=-9.230044e-010       ute=-1.6500857            wute=1.8160371e-007
+ ua1=-3.54593e-010         wua1=1.2238944e-015       ub1=1.1443726e-018
+ wub1=-1.837618e-024       uc1=5.1127043e-011        wuc1=-4.1374792e-017
+ prt=0                     at=92284.115              wat=-0.017393397
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.00                   noia=2e+41                noib=1e+22
+ noic=1e+6                 lintnoi=1.0e-7            jss=4.865e-7
+ jsd=4.865e-7              jsws=2.498e-12            jswd=2.498e-12
+ jswgs=1e-012              jswgd=1e-012              njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.3
+ bvd=9.3                   xjbvs=1                   xjbvd=1
+ jtsswgs=8.75e-010         jtsswgd=8.75e-010         njtsswg=39
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.702
+ pbd=0.702                 cjs=cjn_5m                cjd=cjn_5m
+ mjs=0.308                 mjd=0.308                 pbsws=0.394
+ pbswd=0.394               cjsws=cjswn_5m            cjswd=cjswn_5m
+ mjsws=0.096               mjswd=0.096               pbswgs=0.574
+ pbswgd=0.574              cjswgs=cjswgn_5m          cjswgd=cjswgn_5m
+ mjswgs=0.238              mjswgd=0.238              tpb=1.4e-3
+ tcj=7.372e-4              tpbsw=1.6e-3              tcjsw=5.458e-4
+ tpbswg=4.40e-4            tcjswg=3.95e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lvth0=0+dlvthn_5m         pvth0=0+dpvthn_5m         lu0=0+dlu0n_5m
+ pu0=0+dpu0n_5m            lk2=0+dlk2n_5m            lvsat=0+dlvsatn_5m
+ pvsat=0+dpvsatn_5m        rshg=8.23                 minr=1e-3
 
     8: type=n 
+ lmin=1.2e-006-dxln_5m     lmax=1e-005-dxln_5m       wmin=5e-007-dxwn_5m
+ wmax=1.2e-006-dxwn_5m     version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.41666724+dvthn_5m  lvth0=-2.904311e-009+dlvthn_5m
+ wvth0=-6.2072646e-009+dwvthn_5m                     pvth0=9.0113146e-015+dpvthn_5m
+ k1=0.585                  k2=0.052151503+dk2n_5m    lk2=4.7539859e-009+dlk2n_5m
+ wk2=7.4673117e-010        pk2=-3.0037725e-015       k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00043532428
+ lcit=-1.5157583e-010      wcit=-4.6045678e-011      pcit=2.0025143e-018
+ voff=-0.10146871          lvoff=1.1357641e-010      wvoff=2.4770154e-009
+ pvoff=-7.0088002e-015     nfactor=0.5               eta0=0.0012711571
+ weta0=8.8068986e-010      etab=-0.87985429          wetab=6.3543669e-007
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.050116693+du0n_5m    lu0=5.8285953e-009+dlu0n_5m
+ wu0=-8.4107344e-010+dwu0n_5m                        pu0=-1.8122755e-016+dpu0n_5m
+ ua=9.0069953e-010         lua=-1.2899035e-017       wua=-1.4476805e-017
+ pua=-5.0062859e-024       ub=1.4480571e-018         lub=-5.0489713e-025
+ wub=-4.4936086e-026       pub=-7.120939e-032        uc=5.1725205e-011
+ luc=-1.5620347e-017       wuc=-2.1354965e-017       puc=-1.8393064e-025
+ vsat=85493.073            lvsat=-0.0050233223+dlvsatn_5m
+ wvsat=-0.000102663        pvsat=3.6045258e-009+dpvsatn_5m
+ a0=1.2658359              la0=-7.7962093e-007       wa0=-4.9177663e-008
+ pa0=5.0062879e-014        ags=0.17611773            lags=1.413217e-008
+ wags=-8.8519779e-009      pags=9.0113045e-015       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.003166396         lketa=-3.9333051e-008     wketa=-5.3661222e-009
+ pketa=1.6185321e-014      dwg=0                     dwb=0
+ pclm=0.036963003          lpclm=1.7287952e-007      wpclm=-2.2220609e-008
+ ppclm=4.5056573e-014      pdiblc1=0                 pdiblc2=4.3943441e-005
+ lpdiblc2=6.1655804e-012   wpdiblc2=-1.9671064e-011  ppdiblc2=2.0025141e-017
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.005               pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=39                 beta0=42.8
+ agidl=9.6672168e-014      lagidl=3.2869013e-020     bgidl=7.5e+008
+ cgidl=0.5                 egidl=0.26                aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_5m
+ cgdo=cgon_5m              cgbo=0                    cgdl=cgln_5m
+ cgsl=cgln_5m              clc=1e-007                cle=0.6
+ cf=cfn_5m                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7                    noff=2.5
+ voffcv=-0.05              tvoff=0.0010281091        ltvoff=1.0834308e-009
+ wtvoff=-9.4581756e-010    ptvoff=-1.132624e-016     kt1=-0.34433738
+ lkt1=1.4729244e-008       wkt1=2.6393858e-009       pkt1=-2.0007481e-014
+ kt1l=0                    kt2=-0.046139253          lkt2=5.5622945e-010
+ wkt2=-1.1827519e-009      pkt2=2.550201e-015        ute=-1.6407978
+ lute=-9.1188876e-008      wute=1.7036532e-007       pute=1.1033854e-013
+ ua1=-3.4018846e-010       lua1=-1.4142376e-016      wua1=1.1439927e-015
+ pua1=7.8447508e-022       ub1=1.0903614e-018        lub1=5.3028132e-025
+ wub1=-1.7305198e-024      pub1=-1.0514903e-030      uc1=4.5897141e-011
+ luc1=5.1347173e-017       wuc1=-4.0749052e-017      puc1=-6.1435143e-024
+ prt=0                     at=102827.35              lat=-0.10351345
+ wat=-0.020239005          pat=2.7938177e-008        fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.00
+ noia=2e+41                noib=1e+22                noic=1e+6
+ lintnoi=1.0e-7            jss=4.865e-7              jsd=4.865e-7
+ jsws=2.498e-12            jswd=2.498e-12            jswgs=1e-012
+ jswgd=1e-012              njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.3                   bvd=9.3
+ xjbvs=1                   xjbvd=1                   jtsswgs=8.75e-010
+ jtsswgd=8.75e-010         njtsswg=39                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.702                 pbd=0.702
+ cjs=cjn_5m                cjd=cjn_5m                mjs=0.308
+ mjd=0.308                 pbsws=0.394               pbswd=0.394
+ cjsws=cjswn_5m            cjswd=cjswn_5m            mjsws=0.096
+ mjswd=0.096               pbswgs=0.574              pbswgd=0.574
+ cjswgs=cjswgn_5m          cjswgd=cjswgn_5m          mjswgs=0.238
+ mjswgd=0.238              tpb=1.4e-3                tcj=7.372e-4
+ tpbsw=1.6e-3              tcjsw=5.458e-4            tpbswg=4.40e-4
+ tcjswg=3.95e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   rshg=8.23
+ minr=1e-3
 
     9: type=n 
+ lmin=8.0e-07              lmax=1.2e-006-dxln_5m     wmin=5e-007-dxwn_5m
+ wmax=1.2e-006-dxwn_5m     version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.34612119+dvthn_5m  lvth0=6.8911574e-008+dlvthn_5m
+ wvth0=-1.4413557e-009+dwvthn_5m                     pvth0=4.1596192e-015+dpvthn_5m
+ k1=0.585                  k2=0.045606941+dk2n_5m    lk2=1.141635e-008+dlk2n_5m
+ wk2=2.0183542e-009        pk2=-4.2982847e-015       k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00039070218
+ lcit=-1.0615053e-010      wcit=-1.8146634e-010      pcit=1.3986074e-016
+ voff=-0.072553929         lvoff=-2.9321672e-008     wvoff=-1.1217996e-008
+ pvoff=6.9327218e-015      nfactor=0.5               eta0=0.0012711571
+ weta0=8.8068986e-010      etab=-0.87985429          wetab=6.3543669e-007
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.055978321+du0n_5m    lu0=-1.3854209e-010+dlu0n_5m
+ wu0=-4.9226684e-009+dwu0n_5m                        pu0=3.9738361e-015+dpu0n_5m
+ ua=1.7932661e-009         lua=-9.2153179e-016       wua=-7.8757826e-016
+ pua=7.8201099e-022        ub=-8.926266e-020         lub=1.0600944e-024
+ wub=1.3144259e-024        pub=-1.4550399e-030       uc=7.1363069e-011
+ luc=-3.5611693e-017       wuc=-1.0122805e-017       puc=-1.161827e-023
+ vsat=89519.571            lvsat=-0.009122298+dlvsatn_5m
+ wvsat=0.0034381286        pvsat=1.678568e-022+dpvsatn_5m
+ a0=1.3144358              la0=-8.2909569e-007       wa0=1.3620278e-007
+ pa0=-1.3865441e-013       ags=0.061985747           lags=1.3031853e-007
+ wags=1.3620278e-007       pags=-1.3865444e-013      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.039862361         lketa=-1.9765592e-009     wketa=6.4132971e-009
+ pketa=4.1938724e-015      dwg=0                     dwb=0
+ pclm=-0.25196896          lpclm=4.6701225e-007      wpclm=1.3781167e-007
+ ppclm=-1.1785628e-013     pdiblc1=0                 pdiblc2=-0.0012659626
+ lpdiblc2=1.3396499e-009   wpdiblc2=-3.7060778e-010  ppdiblc2=3.7727872e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.005               pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=39                 beta0=42.8
+ agidl=1.2896e-013         bgidl=7.5e+008            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5m              cgdo=cgon_5m
+ cgbo=0                    cgdl=cgln_5m              cgsl=cgln_5m
+ clc=1e-007                cle=0.6                   cf=cfn_5m
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.007537322         ltvoff=-5.5429479e-009    wtvoff=-5.114421e-009
+ ptvoff=4.1303759e-015     kt1=-0.1863379            lkt1=-1.4611422e-007
+ wkt1=-1.0554189e-007      pkt1=9.0121057e-014       kt1l=0
+ kt2=-0.052424549          lkt2=6.9546615e-009       wkt2=8.6676564e-010
+ pkt2=4.6379216e-016       ute=-2.5570133            lute=8.4151851e-007
+ wute=7.1310357e-007       pute=-4.42169e-013        ua1=-8.3564028e-009
+ lua1=8.0190824e-015       wua1=7.0125313e-015       pua1=-5.1896972e-021
+ ub1=1.1901343e-017        lub1=-1.0475298e-023      wub1=-1.1127699e-023
+ pub1=8.5148379e-030       uc1=1.5607293e-010        luc1=-6.0811776e-017
+ wuc1=-1.1906513e-016      puc1=7.3582254e-023       prt=0
+ at=-23782.913             lat=0.025375798           wat=0.01803105
+ pat=-1.1020739e-008       fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.00                   noia=2e+41
+ noib=1e+22                noic=1e+6                 lintnoi=1.0e-7
+ jss=4.865e-7              jsd=4.865e-7              jsws=2.498e-12
+ jswd=2.498e-12            jswgs=1e-012              jswgd=1e-012
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.3                   bvd=9.3                   xjbvs=1
+ xjbvd=1                   jtsswgs=8.75e-010         jtsswgd=8.75e-010
+ njtsswg=39                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.702                 pbd=0.702                 cjs=cjn_5m
+ cjd=cjn_5m                mjs=0.308                 mjd=0.308
+ pbsws=0.394               pbswd=0.394               cjsws=cjswn_5m
+ cjswd=cjswn_5m            mjsws=0.096               mjswd=0.096
+ pbswgs=0.574              pbswgd=0.574              cjswgs=cjswgn_5m
+ cjswgd=cjswgn_5m          mjswgs=0.238              mjswgd=0.238
+ tpb=1.4e-3                tcj=7.372e-4              tpbsw=1.6e-3
+ tcjsw=5.458e-4            tpbswg=4.40e-4            tcjswg=3.95e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   rshg=8.23                 minr=1e-3
 
     10: type=n 
+ lmin=1e-005-dxln_5m       lmax=900.01e-6            wmin=2.2e-07
+ wmax=5e-007-dxwn_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.40682143+dvthn_5m  wvth0=-4.1892857e-010+dwvthn_5m
+ k1=0.585                  k2=0.058017857+dk2n_5m    wk2=-2.3041071e-009
+ k3=-2.011                 k3b=0.41625               w0=0
+ dvt0=3.6                  dvt1=0.21214              dvt2=0.025
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.296               voffl=0
+ dvtp0=1e-006              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=5.0535e-008          xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0003875             wcit=-2.9325e-011         voff=-0.10111732
+ wvoff=1.5898339e-009      nfactor=0.5               eta0=0.002998
+ etab=0.3661               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.052902143+du0n_5m
+ wu0=-1.9773429e-009+dwu0n_5m                        ua=8.0017857e-010
+ wua=3.5608929e-017        ub=1.5003964e-018         wub=-1.0510918e-025
+ uc=4.3870071e-011         wuc=-1.8178986e-017       vsat=85089.286
+ wvsat=0.00020946429       a0=1.1410714              wa0=-2.0946429e-008
+ ags=0.17054286            wags=-4.3568571e-009      a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.019706            wketa=2.67444e-009        dwg=0
+ dwb=0                     pclm=-0.045714286         wpclm=3.3514286e-008
+ pdiblc1=0                 pdiblc2=-6.4285714e-006   wpdiblc2=8.3785714e-012
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.005               pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=39                 beta0=42.8
+ agidl=1.0002e-013         bgidl=7.5e+008            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5m              cgdo=cgon_5m
+ cgbo=0                    cgdl=cgln_5m              cgsl=cgln_5m
+ clc=1e-007                cle=0.6                   cf=cfn_5m
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=-0.0035257386       ltvoff=0                  wtvoff=1.4213878e-009
+ ptvoff=0                  kt1=-0.38200427           wkt1=2.0576779e-008
+ kt1l=0                    kt2=-0.053906137          wkt2=3.0670004e-009
+ ute=-1.3805786            wute=4.4155071e-008       ua1=1.9682321e-009
+ wua1=3.9253607e-017       ub1=-1.8589929e-018       wub1=-3.0590164e-025
+ uc1=2.2120464e-011        wuc1=-2.6581437e-017      prt=0
+ at=37602.632              wat=0.010494159           fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.00
+ noia=2e+41                noib=1e+22                noic=1e+6
+ lintnoi=1.0e-7            jss=4.865e-7              jsd=4.865e-7
+ jsws=2.498e-12            jswd=2.498e-12            jswgs=1e-012
+ jswgd=1e-012              njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.3                   bvd=9.3
+ xjbvs=1                   xjbvd=1                   jtsswgs=8.75e-010
+ jtsswgd=8.75e-010         njtsswg=39                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.702                 pbd=0.702
+ cjs=cjn_5m                cjd=cjn_5m                mjs=0.308
+ mjd=0.308                 pbsws=0.394               pbswd=0.394
+ cjsws=cjswn_5m            cjswd=cjswn_5m            mjsws=0.096
+ mjswd=0.096               pbswgs=0.574              pbswgd=0.574
+ cjswgs=cjswgn_5m          cjswgd=cjswgn_5m          mjswgs=0.238
+ mjswgd=0.238              tpb=1.4e-3                tcj=7.372e-4
+ tpbsw=1.6e-3              tcjsw=5.458e-4            tpbswg=4.40e-4
+ tcjswg=3.95e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lvth0=0+dlvthn_5m
+ pvth0=0+dpvthn_5m         lu0=0+dlu0n_5m            pu0=0+dpu0n_5m
+ lk2=0+dlk2n_5m            lvsat=0+dlvsatn_5m        pvsat=0+dpvsatn_5m
+ rshg=8.23                 minr=1e-3
 
     11: type=n 
+ lmin=1.2e-006-dxln_5m     lmax=1e-005-dxln_5m       wmin=2.2e-07
+ wmax=5e-007-dxwn_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.40294196+dvthn_5m  lvth0=3.808866e-008+dlvthn_5m
+ wvth0=7.926319e-010+dwvthn_5m                       pvth0=-1.1895101e-014+dpvthn_5m
+ k1=0.585                  k2=0.057895978+dk2n_5m    lk2=1.1966086e-009+dlk2n_5m
+ wk2=-2.1829511e-009       pk2=-1.1895101e-015       k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00040092322
+ lcit=-1.3178922e-010      wcit=-2.850114e-011       pcit=-8.088659e-018
+ voff=-0.09818927          lvoff=-2.8747609e-008     wvoff=8.0450043e-010
+ pvoff=7.7104043e-015      nfactor=0.5               eta0=0.002998
+ etab=0.3661               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.052332889+du0n_5m
+ lu0=5.5889328e-009+dlu0n_5m                         wu0=-1.9713335e-009+dwu0n_5m
+ pu0=-5.89997e-017+dpu0n_5m                          ua=7.8795348e-010
+ lua=1.2002593e-016        wua=4.3023679e-017        pua=-7.2798016e-023
+ ub=1.5824381e-018         lub=-8.0548507e-025       wub=-1.134704e-025
+ pub=8.2090459e-032        uc=4.5746731e-011         luc=-1.8425044e-017
+ wuc=-1.8305944e-017       puc=1.2464646e-024        vsat=84538.971
+ lvsat=0.005402992+dlvsatn_5m                        wvsat=0.00038392899
+ pvsat=-1.7128945e-009+dpvsatn_5m                    a0=1.1914756
+ la0=-4.9486853e-007       wa0=-1.1253941e-008       pa0=-9.5160844e-014
+ ags=0.16449105            lags=5.9416687e-008       wags=-2.9223696e-009
+ pags=-1.4083799e-014      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.018687516
+ lketa=-9.9994719e-009     wketa=2.5496492e-009      pketa=1.2251959e-015
+ dwg=0                     dwb=0                     pclm=-0.099403045
+ lpclm=5.2711624e-007      wpclm=4.7326076e-008      ppclm=-1.3560416e-013
+ pdiblc1=0                 pdiblc2=-1.5807062e-005   lpdiblc2=9.2078018e-011
+ wpdiblc2=1.0801692e-011   ppdiblc2=-2.3790202e-017  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.005
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=39                 beta0=42.8                agidl=9.6672168e-014
+ lagidl=3.2869013e-020     bgidl=7.5e+008            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5m              cgdo=cgon_5m
+ cgbo=0                    cgdl=cgln_5m              cgsl=cgln_5m
+ clc=1e-007                cle=0.6                   cf=cfn_5m
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=-0.0037721693       ltvoff=2.4194564e-009     wtvoff=1.5023244e-009
+ ptvoff=-7.9463548e-016    kt1=-0.37917022           lkt1=-2.7824612e-008
+ wkt1=2.0404138e-008       pkt1=1.6949852e-015       kt1l=0
+ kt2=-0.055216051          lkt2=1.2860734e-008       wkt2=3.4464154e-009
+ pkt2=-3.7250964e-015      ute=-1.4224232            lute=4.1083021e-007
+ wute=5.8994264e-008       pute=-1.4569119e-013      ua1=1.5897437e-009
+ lua1=3.7159997e-015       wua1=1.5972732e-016       pua1=-1.1828109e-021
+ ub1=-1.3349753e-018       lub1=-5.1448042e-024      wub1=-4.9359805e-025
+ pub1=1.8428034e-030       uc1=2.9189723e-011        luc1=-6.9405977e-017
+ wuc1=-3.2228268e-017      puc1=5.5440592e-023       prt=0
+ at=39487.167              lat=-0.018502363          wat=0.012064486
+ pat=-1.5417475e-008       fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.00                   noia=2e+41
+ noib=1e+22                noic=1e+6                 lintnoi=1.0e-7
+ jss=4.865e-7              jsd=4.865e-7              jsws=2.498e-12
+ jswd=2.498e-12            jswgs=1e-012              jswgd=1e-012
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.3                   bvd=9.3                   xjbvs=1
+ xjbvd=1                   jtsswgs=8.75e-010         jtsswgd=8.75e-010
+ njtsswg=39                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.702                 pbd=0.702                 cjs=cjn_5m
+ cjd=cjn_5m                mjs=0.308                 mjd=0.308
+ pbsws=0.394               pbswd=0.394               cjsws=cjswn_5m
+ cjswd=cjswn_5m            mjsws=0.096               mjswd=0.096
+ pbswgs=0.574              pbswgd=0.574              cjswgs=cjswgn_5m
+ cjswgd=cjswgn_5m          mjswgs=0.238              mjswgd=0.238
+ tpb=1.4e-3                tcj=7.372e-4              tpbsw=1.6e-3
+ tcjsw=5.458e-4            tpbswg=4.40e-4            tcjswg=3.95e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   rshg=8.23                 minr=1e-3
 
     12: type=n 
+ lmin=8.0e-07              lmax=1.2e-006-dxln_5m     wmin=2.2e-07
+ wmax=5e-007-dxwn_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_5m              toxm=toxn_5m              dtox=8.5e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_5m
+ xw=1e-08+dxwn_5m          dlc=2.3e-008              dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=0.35576839+dvthn_5m  lvth0=8.6111348e-008+dlvthn_5m
+ wvth0=-6.3614304e-009+dwvthn_5m                     pvth0=-4.6122653e-015+dpvthn_5m
+ k1=0.585                  k2=0.065019676+dk2n_5m    lk2=-6.0553156e-009+dlk2n_5m
+ wk2=-7.8821404e-009       pk2=4.6122647e-015        k3=-2.011
+ k3b=0.41625               w0=0                      dvt0=3.6
+ dvt1=0.21214              dvt2=0.025                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.296               voffl=0                   dvtp0=1e-006
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=5.0535e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00027149898
+ lcit=-3.5333738e-014      wcit=-1.206727e-010       pcit=8.5741993e-017
+ voff=-0.0982875           lvoff=-2.8647611e-008     wvoff=1.906125e-009
+ pvoff=6.5889505e-015      nfactor=0.5               eta0=0.002998
+ etab=0.3661               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.051739121+du0n_5m
+ lu0=6.1933888e-009+dlu0n_5m                         wu0=-2.7606765e-009+dwu0n_5m
+ pu0=7.445514e-016+dpu0n_5m                          ua=-1.4060446e-010
+ lua=1.0652979e-015        wua=1.9869573e-016        pua=-2.3127216e-022
+ ub=3.5173717e-018         lub=-2.7752474e-024       wub=-5.2495757e-025
+ pub=5.009844e-031         uc=5.9113122e-011         luc=-3.2032029e-017
+ wuc=-3.8753313e-018       puc=-1.3443899e-023       vsat=103725.22
+ lvsat=-0.014128608+dlvsatn_5m                       wvsat=-0.0038067516
+ pvsat=2.5532183e-009+dpvsatn_5m                     a0=2.4848664
+ la0=-1.8115403e-006       wa0=-4.607168e-007        pa0=3.6239234e-013
+ ags=0.4380536             lags=-2.1906999e-007      wags=-5.5591828e-008
+ pags=3.9533709e-014       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.020920158
+ lketa=-7.7266429e-009     wketa=-3.2472263e-009     pketa=7.1264151e-015
+ dwg=0                     dwb=0                     pclm=0.35573872
+ lpclm=6.378192e-008       wpclm=-1.7211925e-007     ppclm=8.7791186e-014
+ pdiblc1=0                 pdiblc2=-0.0025290739     lpdiblc2=2.6505837e-009
+ wpdiblc2=2.73579e-010     ppdiblc2=-2.912975e-016   pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.005
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=39                 beta0=42.8                agidl=1.2896e-013
+ bgidl=7.5e+008            cgidl=0.5                 egidl=0.26
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_5m              cgdo=cgon_5m              cgbo=0
+ cgdl=cgln_5m              cgsl=cgln_5m              clc=1e-007
+ cle=0.6                   cf=cfn_5m                 ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7
+ noff=2.5                  voffcv=-0.05              tvoff=-0.0018231297
+ ltvoff=4.3533412e-010     wtvoff=-3.4059063e-010    ptvoff=1.081452e-015
+ kt1=-0.45462979           lkt1=4.8993223e-008       wkt1=3.1286972e-008
+ pkt1=-9.3837395e-015      kt1l=0                    kt2=-0.047404212
+ lkt2=4.9082818e-009       wkt2=-1.6936064e-009      pkt2=1.5074458e-015
+ ute=-0.73899143           lute=-2.849033e-007       wute=-2.1408758e-007
+ pute=1.3230613e-013       ua1=1.1432048e-008        lua1=-6.3034662e-015
+ wua1=-3.0795787e-015      pua1=2.1148026e-021       ub1=-1.9213408e-017
+ lub1=1.305544e-023        wub1=4.7408239e-024       pub1=-3.4858382e-030
+ uc1=-1.8833036e-010       luc1=1.5202946e-016       wuc1=5.6580543e-017
+ puc1=-3.4966778e-023      prt=0                     at=22327.093
+ lat=-0.0010334075         wat=-0.0054850532         pat=2.4479557e-009
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.00                   noia=2e+41                noib=1e+22
+ noic=1e+6                 lintnoi=1.0e-7            jss=4.865e-7
+ jsd=4.865e-7              jsws=2.498e-12            jswd=2.498e-12
+ jswgs=1e-012              jswgd=1e-012              njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.3
+ bvd=9.3                   xjbvs=1                   xjbvd=1
+ jtsswgs=8.75e-010         jtsswgd=8.75e-010         njtsswg=39
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.702
+ pbd=0.702                 cjs=cjn_5m                cjd=cjn_5m
+ mjs=0.308                 mjd=0.308                 pbsws=0.394
+ pbswd=0.394               cjsws=cjswn_5m            cjswd=cjswn_5m
+ mjsws=0.096               mjswd=0.096               pbswgs=0.574
+ pbswgd=0.574              cjswgs=cjswgn_5m          cjswgd=cjswgn_5m
+ mjswgs=0.238              mjswgd=0.238              tpb=1.4e-3
+ tcj=7.372e-4              tpbsw=1.6e-3              tcjsw=5.458e-4
+ tpbswg=4.40e-4            tcjswg=3.95e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ rshg=8.23                 minr=1e-3
 
// *********************************************************************************************
//                                                                            
//                   *
//                                 5V MED-VT PMOS DEVICE MODELS               
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
// *********************************
//        Macro   model            *
// *********************************
 
     } 
inline subckt mepch5_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2e-007 dmci=2e-007 
+ xw=1e-08 + dxwp_5m ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf 
+ * dmcg + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor 
+ + (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 
+ 1) * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=0 / factor sb=0 / factor sd=2 * dmcg 
+ / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_5m 
+ temp1=par1p_5m temp2=par2p_5m fac1=0.95506 * temp1 * sigma + 0.29641 * temp2 * 
+ sigma fac2=0.95506 * temp1 * sigma - 0.29641 * temp2 * sigma lef=l * factor - 
+ 3e-08 wef=w / nf * factor + 1e-08 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) 
+ vthmisp_5m=4.895e-3 * geo_fac * fac1 * mismatchflag dlmisp_5m=1.897e-3 * geo_fac 
+ * lef * fac2 * mismatchflag dwmisp_5m= - 1.897e-3 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisp_5m=1.897e-3 * geo_fac * toxp_5m * fac2 * mismatchflag 
mepch5_mac ( n1 n2 n3 n4 ) mepch5 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
 
model mepch5 bsim4  { 
     1: type=p 
+ lmin=1e-005-dxlp_5m+dlmisp_5m                       lmax=900.01e-6
+ wmin=1e-005-dxwp_5m+dwmisp_5m                       wmax=900.01e-6
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.40989+dvthp_5m+vthmisp_5m
+ k1=0.6596                 k2=0.045107+dk2p_5m       k3=0
+ k3b=0.14                  w0=0                      dvt0=1.3
+ dvt1=0.26936              dvt2=0.03                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56029329
+ minv=-0.195               voffl=0                   dvtp0=4.5e-007
+ dvtp1=0.1                 lpe0=7e-008               lpeb=2.5e-008
+ xj=1.5e-007               ngate=1.5e+021            ndep=1.424026e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0004301
+ voff=-0.12776             nfactor=0.5               eta0=0.014269
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.01614+du0p_5m
+ ua=2.465e-009             ub=6.4203e-020            uc=-4.5033e-011
+ vsat=85000                a0=1.25                   ags=0.1356
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0032943           dwg=0
+ dwb=0                     pclm=0.3                  pdiblc1=0
+ pdiblc2=0.00021           pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=6.7
+ beta0=37.6                agidl=2.6361e-012         bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5m
+ cgdo=cgop_5m              cgbo=0                    cgdl=cglp_5m
+ cgsl=cglp_5m              clc=1e-007                cle=0.6
+ cf=cfp_5m                 ckappas=0.6               ckappad=0.6
+ acde=1                    moin=23.25                noff=2.4
+ voffcv=-0.028             tvoff=0.0041635686        ltvoff=0
+ wtvoff=0                  ptvoff=0                  kt1=-0.28526
+ kt1l=0                    kt2=-0.038751             ute=-1.3256
+ ua1=-6.761e-010           ub1=-1.342e-018           uc1=-8.4585e-012
+ prt=0                     at=139000                 fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   pu0=0+dpu0p_5m
+ wu0=0+dwu0p_5m            lu0=0+dlu0p_5m            lvth0=0+dlvthp_5m
+ wvth0=0+dwvthp_5m         pvth0=0+dpvthp_5m         wk2=0+dwk2p_5m
+ lvsat=0+dlvsatp_5m        pvsat=0+dpvsatp_5m        rshg=8.41
+ minr=1e-3
 
     2: type=p 
+ lmin=1.2e-006-dxlp_5m+dlmisp_5m                     lmax=1e-005-dxlp_5m+dlmisp_5m
+ wmin=1e-005-dxwp_5m+dwmisp_5m                       wmax=900.01e-6
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.408436+dvthp_5m+vthmisp_5m
+ lvth0=-1.4275419e-008+dlvthp_5m                     k1=0.6596
+ k2=0.04487788+dk2p_5m     lk2=2.2494978e-009        k3=0
+ k3b=0.14                  w0=0                      dvt0=1.3
+ dvt1=0.26936              dvt2=0.03                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56029329
+ minv=-0.195               voffl=0                   dvtp0=4.5e-007
+ dvtp1=0.1                 lpe0=7e-008               lpeb=2.5e-008
+ xj=1.5e-007               ngate=1.5e+021            ndep=1.424026e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00041484764
+ lcit=1.4974768e-010       voff=-0.12999046          lvoff=2.1898667e-008
+ nfactor=0.5               eta0=0.014269045          leta0=-4.4181223e-013
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.016224566+du0p_5m
+ lu0=-8.3026513e-010+dlu0p_5m                        ua=2.4593316e-009
+ lua=5.5652441e-017        ub=5.2635165e-020         lub=1.13573e-025
+ uc=-4.594839e-011         luc=8.9873013e-018        vsat=85000
+ a0=1.3059788              la0=-5.4959983e-007       ags=0.13098226
+ lags=4.5336999e-008       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.00068038834
+ lketa=-2.5663385e-008     dwg=0                     dwb=0
+ pclm=0.2900398            lpclm=9.7789288e-008      pdiblc1=0
+ pdiblc2=0.00013943409     lpdiblc2=6.928161e-010    pdiblcb=-0.2
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=4.11e+008          pscbe2=1e-006             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.49                  rdsw=1000                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=6.7                beta0=37.6                agidl=2.6009212e-012
+ lagidl=3.4538586e-019     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5m              cgdo=cgop_5m
+ cgbo=0                    cgdl=cglp_5m              cgsl=cglp_5m
+ clc=1e-007                cle=0.6                   cf=cfp_5m
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=23.25                noff=2.4                  voffcv=-0.028
+ tvoff=0.0040568059        ltvoff=1.0481966e-009     wtvoff=0
+ ptvoff=0                  kt1=-0.28142283           lkt1=-3.7673295e-008
+ kt1l=0                    kt2=-0.038370638          lkt2=-3.7343923e-009
+ ute=-1.3153853            lute=-1.0028797e-007      ua1=-6.0334771e-010
+ lua1=-7.1428204e-016      ub1=-1.2868429e-018       lub1=-5.4153232e-025
+ uc1=-1.085456e-011        luc1=2.3524515e-017       prt=0
+ at=157410.53              lat=-0.18075458           fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   pu0=0+dpu0p_5m
+ wu0=0+dwu0p_5m            wvth0=0+dwvthp_5m         pvth0=0+dpvthp_5m
+ wk2=0+dwk2p_5m            lvsat=0+dlvsatp_5m        pvsat=0+dpvsatp_5m
+ rshg=8.41                 minr=1e-3
 
     3: type=p 
+ lmin=8e-07                lmax=1.2e-006-dxlp_5m+dlmisp_5m
+ wmin=1e-005-dxwp_5m+dwmisp_5m                       wmax=900.01e-6
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.42780316+dvthp_5m+vthmisp_5m
+ lvth0=5.4403498e-009+dlvthp_5m                      k1=0.6596
+ k2=0.046295948+dk2p_5m    lk2=8.059047e-010         k3=0
+ k3b=0.14                  w0=0                      dvt0=1.3
+ dvt1=0.26936              dvt2=0.03                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56029329
+ minv=-0.195               voffl=0                   dvtp0=4.5e-007
+ dvtp1=0.1                 lpe0=7e-008               lpeb=2.5e-008
+ xj=1.5e-007               ngate=1.5e+021            ndep=1.424026e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00060000456
+ lcit=-3.8742069e-011      voff=-0.10651531          lvoff=-1.9990415e-009
+ nfactor=0.5               eta0=0.014268613          leta0=-1.57281e-015
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.015913122+du0p_5m
+ lu0=-5.1321577e-010+dlu0p_5m                        ua=2.47383e-009
+ lua=4.089306e-017         ub=9.86995e-021           lub=1.5710799e-025
+ uc=-5.622547e-011         luc=1.9449369e-017        vsat=85000
+ a0=1.3351091              la0=-5.7925452e-007       ags=0.32463736
+ lags=-1.5180389e-007      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.019862955
+ lketa=-6.1355318e-009     dwg=0                     dwb=0
+ pclm=0.25647449           lpclm=1.3195878e-007      pdiblc1=0
+ pdiblc2=-0.00084860016    lpdiblc2=1.698635e-009    pdiblcb=-0.2
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=4.11e+008          pscbe2=1e-006             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.49                  rdsw=1000                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=6.7                beta0=37.6                agidl=3.620309e-012
+ lagidl=-6.9235096e-019    bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5m              cgdo=cgop_5m
+ cgbo=0                    cgdl=cglp_5m              cgsl=cglp_5m
+ clc=1e-007                cle=0.6                   cf=cfp_5m
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=23.25                noff=2.4                  voffcv=-0.028
+ tvoff=0.0052725593        ltvoff=-1.894404e-010     wtvoff=0
+ ptvoff=0                  kt1=-0.2996843            lkt1=-1.9083124e-008
+ kt1l=0                    kt2=-0.039481779          lkt2=-2.6032506e-009
+ ute=-1.3613699            lute=-5.3475697e-008      ua1=3.1513455e-012
+ lua1=-1.3316981e-015      ub1=-4.5528475e-018       lub1=2.7832604e-024
+ uc1=-4.7015288e-011       luc1=6.0336136e-017       prt=0
+ at=7385.4476              lat=-0.028029049          fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   pu0=0+dpu0p_5m
+ wu0=0+dwu0p_5m            wvth0=0+dwvthp_5m         pvth0=0+dpvthp_5m
+ wk2=0+dwk2p_5m            lvsat=0+dlvsatp_5m        pvsat=0+dpvsatp_5m
+ rshg=8.41                 minr=1e-3
 
     4: type=p 
+ lmin=1e-005-dxlp_5m+dlmisp_5m                       lmax=900.01e-6
+ wmin=1.2e-006-dxwp_5m+dwmisp_5m                     wmax=1e-005-dxwp_5m+dwmisp_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.41124988+dvthp_5m+vthmisp_5m
+ wvth0=1.3612349e-008+dwvthp_5m                      k1=0.6596
+ k2=0.045465463+dk2p_5m    wk2=-3.5882096e-009+dwk2p_5m
+ k3=0                      k3b=0.14                  w0=0
+ dvt0=1.3                  dvt1=0.26936              dvt2=0.03
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.195               voffl=0
+ dvtp0=4.5e-007            dvtp1=0.1                 lpe0=7e-008
+ lpeb=2.5e-008             xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00047505288         wcit=-4.4997828e-010      voff=-0.12765138
+ wvoff=-1.0873363e-009     nfactor=0.5               eta0=0.012271125
+ weta0=1.9998729e-008      etab=-0.061               ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.016530225+du0p_5m    wu0=-3.9061523e-009+dwu0p_5m
+ ua=2.5275625e-009         wua=-6.2625063e-016       ub=7.766535e-020
+ wub=-1.3475812e-025       uc=-4.0981838e-011        wuc=-4.0552137e-017
+ vsat=85000                a0=1.256875               wa0=-6.881875e-008
+ ags=0.137085              wags=-1.486485e-008       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.004304375         wketa=1.0110851e-008      dwg=0
+ dwb=0                     pclm=0.28625              wpclm=1.376375e-007
+ pdiblc1=0                 pdiblc2=0.0002290575      wpdiblc2=-1.9076558e-010
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=6.7                beta0=37.6
+ agidl=1.4860638e-012      wagidl=1.1511863e-017     bgidl=1.0635e+009
+ wbgidl=44.044             cgidl=150                 egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_5m              cgdo=cgop_5m              cgbo=0
+ cgdl=cglp_5m              cgsl=cglp_5m              clc=1e-007
+ cle=0.6                   cf=cfp_5m                 ckappas=0.6
+ ckappad=0.6               acde=1                    moin=23.25
+ noff=2.4                  voffcv=-0.028             tvoff=0.0042452848
+ ltvoff=0                  wtvoff=-8.1797925e-010    ptvoff=0
+ kt1=-0.28478288           wkt1=-4.7760213e-009      kt1l=0
+ kt2=-0.038580363          wkt2=-1.7080814e-009      ute=-1.3310038
+ wute=5.4091538e-008       ua1=-6.78179e-010         wua1=2.081079e-017
+ ub1=-1.3894953e-018       wub1=4.7542745e-025       uc1=-1.6361244e-011
+ wuc1=7.9106469e-017       prt=0                     at=139257.13
+ wat=-0.0025738213         fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.13                   noia=4.2e+40
+ noib=1.6e+24              noic=1.5e+9               lintnoi=-1.0e-7
+ jss=7.434e-7              jsd=7.434e-7              jsws=1.117e-11
+ jswd=1.117e-11            jswgs=1.8e-011            jswgd=1.8e-011
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.7                   bvd=9.7                   xjbvs=1
+ xjbvd=1                   jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=25.9              xtsswgs=0.48              xtsswgd=0.48
+ tnjtsswg=1                vtsswgs=3                 vtsswgd=3
+ pbs=0.818                 pbd=0.818                 cjs=cjp_5m
+ cjd=cjp_5m                mjs=0.359                 mjd=0.359
+ pbsws=0.721               pbswd=0.721               cjsws=cjswp_5m
+ cjswd=cjswp_5m            mjsws=0.366               mjswd=0.366
+ pbswgs=0.721              pbswgd=0.721              cjswgs=cjswgp_5m
+ cjswgd=cjswgp_5m          mjswgs=0.366              mjswgd=0.366
+ tpb=1.41e-03              tcj=7.56e-04              tpbsw=8.25e-04
+ tcjsw=6.43e-04            tpbswg=8.25e-4            tcjswg=6.43e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   pu0=0+dpu0p_5m            lu0=0+dlu0p_5m
+ lvth0=0+dlvthp_5m         pvth0=0+dpvthp_5m         lvsat=0+dlvsatp_5m
+ pvsat=0+dpvsatp_5m        rshg=8.41                 minr=1e-3
 
     5: type=p 
+ lmin=1.2e-006-dxlp_5m+dlmisp_5m                     lmax=1e-005-dxlp_5m+dlmisp_5m
+ wmin=1.2e-006-dxwp_5m+dwmisp_5m                     wmax=1e-005-dxwp_5m+dwmisp_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.40926464+dvthp_5m+vthmisp_5m
+ lvth0=-1.9491039e-008+dlvthp_5m                     wvth0=8.2947323e-009+dwvthp_5m
+ pvth0=5.2208358e-014+dpvthp_5m                      k1=0.6596
+ k2=0.045188933+dk2p_5m    lk2=2.7149711e-009        wk2=-3.1136335e-009+dwk2p_5m
+ pk2=-4.6593882e-015       k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00046296627         lcit=1.1866633e-010
+ wcit=-4.8166746e-010      pcit=3.1112434e-016       voff=-0.13003105
+ lvoff=2.3363675e-008      wvoff=4.0632123e-010      pvoff=-1.4664729e-014
+ nfactor=0.5               eta0=0.012271178          leta0=-5.2036452e-013
+ weta0=1.9998649e-008      peta0=7.8630836e-019      etab=-0.061
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.016619325+du0p_5m    lu0=-8.74786e-010+dlu0p_5m
+ wu0=-3.9515438e-009+dwu0p_5m                        pu0=4.4565394e-016+dpu0p_5m
+ ua=2.5244852e-009         lua=3.0212745e-017        wua=-6.5218782e-016
+ pua=2.5465136e-022        ub=6.6702557e-020         lub=1.076327e-025
+ wub=-1.4081459e-025       pub=5.946242e-032         uc=-4.1887318e-011
+ luc=8.8900089e-018        wuc=-4.0651332e-017       puc=9.7389684e-025
+ vsat=85000                a0=1.3147486              la0=-5.6820257e-007
+ wa0=-8.7785277e-008       pa0=1.8621336e-013        ags=0.13290501
+ lags=4.1039157e-008       wags=-1.924674e-008       pags=4.30214e-014
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0018602626        lketa=-2.3996296e-008
+ wketa=1.1810541e-008      pketa=-1.6687558e-014     dwg=0
+ dwb=0                     pclm=0.27331851           lpclm=1.2696139e-007
+ wpclm=1.6738009e-007      ppclm=-2.9201273e-013     pdiblc1=0
+ pdiblc2=0.00016276401     lpdiblc2=6.5086949e-010   wpdiblc2=-2.3353249e-010
+ ppdiblc2=4.1988554e-016   pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=6.7
+ beta0=37.6                agidl=1.3613868e-012      lagidl=1.2240783e-018
+ wagidl=1.2407739e-017     pagidl=-8.7957108e-024    bgidl=1.062991e+009
+ lbgidl=4.997362           wbgidl=49.13909           pbgidl=-5.0023594e-005
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5m
+ cgdo=cgop_5m              cgbo=0                    cgdl=cglp_5m
+ cgsl=cglp_5m              clc=1e-007                cle=0.6
+ cf=cfp_5m                 ckappas=0.6               ckappad=0.6
+ acde=1                    moin=23.25                noff=2.4
+ voffcv=-0.028             tvoff=0.00412156          ltvoff=1.21473e-009
+ wtvoff=-6.4818907e-010    ptvoff=-1.667e-015        kt1=-0.28087572
+ lkt1=-3.8360432e-008      wkt1=-5.4765961e-009      pkt1=6.8782441e-015
+ kt1l=0                    kt2=-0.0381648            lkt2=-4.0799912e-009
+ wkt2=-2.0604387e-009      pkt2=3.4594442e-015       ute=-1.3208177
+ lute=-1.0000687e-007      wute=5.4378136e-008       pute=-2.8138271e-015
+ ua1=-6.047701e-010        lua1=-7.2072863e-016      wua1=1.4238124e-017
+ pua1=6.4530436e-023       ub1=-1.3356619e-018       lub1=-5.2853605e-025
+ wub1=4.8867787e-025       pub1=-1.3009261e-031      uc1=-1.9476593e-011
+ luc1=3.058649e-017        wuc1=8.6306548e-017       puc1=-7.0690374e-023
+ prt=0                     at=157576.53              lat=-0.1798599
+ wat=-0.0016616409         pat=-8.9557865e-009       fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lvsat=0+dlvsatp_5m
+ pvsat=0+dpvsatp_5m        rshg=8.41                 minr=1e-3
 
     6: type=p 
+ lmin=8e-07                lmax=1.2e-006-dxlp_5m+dlmisp_5m
+ wmin=1.2e-006-dxwp_5m+dwmisp_5m                     wmax=1e-005-dxwp_5m+dwmisp_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.43169192+dvthp_5m+vthmisp_5m
+ lvth0=3.3399307e-009+dlvthp_5m                      wvth0=3.8926523e-008+dwvthp_5m
+ pvth0=2.1025196e-014+dpvthp_5m                      k1=0.6596
+ k2=0.046891659+dk2p_5m    lk2=9.8159522e-010        wk2=-5.9630697e-009+dwk2p_5m
+ pk2=-1.7586622e-015       k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00063011442         lcit=-5.1490498e-011
+ wcit=-3.0139971e-010      pcit=1.2761177e-016       voff=-0.10421372
+ lvoff=-2.9183686e-009     wvoff=-2.3038859e-008     pvoff=9.2024643e-015
+ nfactor=0.5               eta0=0.012270669          leta0=-1.7890714e-015
+ weta0=1.9999419e-008      peta0=2.1647764e-021      etab=-0.061
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.016257826+du0p_5m    lu0=-5.0677983e-010+dlu0p_5m
+ wu0=-3.4504851e-009+dwu0p_5m                        pu0=-6.4423745e-017+dpu0p_5m
+ ua=2.5271861e-009         lua=2.7463229e-017        wua=-5.3409475e-016
+ pua=1.3443261e-022        ub=-1.7130049e-020        lub=1.9297429e-025
+ wub=2.7026999e-025        pub=-3.5902168e-031       uc=-5.2687607e-011
+ luc=1.9884703e-017        wuc=-3.5414012e-017       puc=-4.3576948e-024
+ vsat=85000                a0=1.3538753              la0=-6.0803363e-007
+ wa0=-1.8784965e-007       pa0=2.8807889e-013        ags=0.34279159
+ lags=-1.7262538e-007      wags=-1.8172388e-007      pags=2.0842313e-013
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.017873756         lketa=-7.6945601e-009
+ wketa=-1.9911886e-008     pketa=1.5605873e-014      dwg=0
+ dwb=0                     pclm=0.30809281           lpclm=9.156115e-008
+ wpclm=-5.1669943e-007     ppclm=4.0438023e-013      pdiblc1=0
+ pdiblc2=-0.0010003108     lpdiblc2=1.8348796e-009   wpdiblc2=1.5186234e-009
+ ppdiblc2=-1.3638091e-015  pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=6.7
+ beta0=37.6                agidl=2.949768e-012       lagidl=-3.9289381e-019
+ wagidl=6.7121153e-018     pagidl=-2.9975661e-024    bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5m
+ cgdo=cgop_5m              cgbo=0                    cgdl=cglp_5m
+ cgsl=cglp_5m              clc=1e-007                cle=0.6
+ cf=cfp_5m                 ckappas=0.6               ckappad=0.6
+ acde=1                    moin=23.25                noff=2.4
+ voffcv=-0.028             tvoff=0.0055795526        ltvoff=-2.6950642e-010
+ wtvoff=-3.0730032e-009    ptvoff=8.0146082e-016     kt1=-0.30364253
+ lkt1=-1.5183817e-008      wkt1=3.962194e-008        pkt1=-3.9032065e-014
+ kt1l=0                    kt2=-0.039799366          lkt2=-2.4160029e-009
+ wkt2=3.1790447e-009       pkt2=-1.87435e-015        ute=-1.3570089
+ lute=-6.3164207e-008      wute=-4.365311e-008       pute=9.6981981e-014
+ ua1=1.2179664e-010        lua1=-1.4603736e-015      wua1=-1.1876394e-015
+ pua1=1.2880417e-021       ub1=-4.707506e-018        lub1=2.9040013e-024
+ wub1=1.5481314e-024       pub1=-1.2086163e-030      uc1=-5.1303422e-011
+ luc1=6.2986203e-017       wuc1=4.292423e-017        puc1=-2.6527174e-023
+ prt=0                     at=5576.8498              lat=-0.025124226
+ wat=0.018104064           pat=-2.9077274e-008       fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lvsat=0+dlvsatp_5m
+ pvsat=0+dpvsatp_5m        rshg=8.41                 minr=1e-3
 
     7: type=p 
+ lmin=1e-005-dxlp_5m+dlmisp_5m                       lmax=900.01e-6
+ wmin=5e-007-dxwp_5m+dwmisp_5m                       wmax=1.2e-006-dxwp_5m+dwmisp_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.4051+dvthp_5m+vthmisp_5m
+ wvth0=6.171e-009+dwvthp_5m                          k1=0.6596
+ k2=0.043592857+dk2p_5m    wk2=-1.3223571e-009+dwk2p_5m
+ k3=0                      k3b=0.14                  w0=0
+ dvt0=1.3                  dvt1=0.26936              dvt2=0.03
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.195               voffl=0
+ dvtp0=4.5e-007            dvtp1=0.1                 lpe0=7e-008
+ lpeb=2.5e-008             xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=3.2622429e-005        wcit=8.5362561e-011       voff=-0.12856457
+ wvoff=1.7631429e-011      nfactor=0.5               eta0=0.0085928
+ weta0=2.4449502e-008      etab=-0.061               ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.013629857+du0p_5m    wu0=-3.9670714e-010+dwu0p_5m
+ ua=2.3888571e-009         wua=-4.5841714e-016       ub=-1.3111864e-019
+ wub=1.1787051e-025        uc=-6.0347871e-011        wuc=-1.7119236e-017
+ vsat=85000                a0=1.1854286              wa0=1.7631429e-008
+ ags=0.13172143            wags=-8.3749286e-009      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.0040893671         wketa=-4.5577243e-011     dwg=0
+ dwb=0                     pclm=0.49471429           wpclm=-1.1460429e-007
+ pdiblc1=0                 pdiblc2=7.9705714e-005    wpdiblc2=-1.0049914e-011
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=6.7                beta0=37.6
+ agidl=8e-013              wagidl=1.2342e-017        bgidl=1.0843086e+009
+ wbgidl=18.865629          cgidl=150                 egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_5m              cgdo=cgop_5m              cgbo=0
+ cgdl=cglp_5m              cgsl=cglp_5m              clc=1e-007
+ cle=0.6                   cf=cfp_5m                 ckappas=0.6
+ ckappad=0.6               acde=1                    moin=23.25
+ noff=2.4                  voffcv=-0.028             tvoff=0.0036735767
+ ltvoff=0                  wtvoff=-1.2621238e-010    ptvoff=0
+ kt1=-0.28039575           wkt1=-1.0084445e-008      kt1l=0
+ kt2=-0.039555042          wkt2=-5.2871894e-010      ute=-1.2848059
+ wute=-1.8078385e-009      ua1=-5.3663471e-010       wua1=-1.504578e-016
+ ub1=-1.801207e-018        wub1=9.7359867e-025       uc1=4.9016005e-011
+ wuc1=-2.6447143e-024      prt=0                     at=139617.34
+ wat=-0.0030096849         fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.13                   noia=4.2e+40
+ noib=1.6e+24              noic=1.5e+9               lintnoi=-1.0e-7
+ jss=7.434e-7              jsd=7.434e-7              jsws=1.117e-11
+ jswd=1.117e-11            jswgs=1.8e-011            jswgd=1.8e-011
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.7                   bvd=9.7                   xjbvs=1
+ xjbvd=1                   jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=25.9              xtsswgs=0.48              xtsswgd=0.48
+ tnjtsswg=1                vtsswgs=3                 vtsswgd=3
+ pbs=0.818                 pbd=0.818                 cjs=cjp_5m
+ cjd=cjp_5m                mjs=0.359                 mjd=0.359
+ pbsws=0.721               pbswd=0.721               cjsws=cjswp_5m
+ cjswd=cjswp_5m            mjsws=0.366               mjswd=0.366
+ pbswgs=0.721              pbswgd=0.721              cjswgs=cjswgp_5m
+ cjswgd=cjswgp_5m          mjswgs=0.366              mjswgd=0.366
+ tpb=1.41e-03              tcj=7.56e-04              tpbsw=8.25e-04
+ tcjsw=6.43e-04            tpbswg=8.25e-4            tcjswg=6.43e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   pu0=0+dpu0p_5m            lu0=0+dlu0p_5m
+ lvth0=0+dlvthp_5m         pvth0=0+dpvthp_5m         lvsat=0+dlvsatp_5m
+ pvsat=0+dpvsatp_5m        rshg=8.41                 minr=1e-3
 
     8: type=p 
+ lmin=1.2e-006-dxlp_5m+dlmisp_5m                     lmax=1e-005-dxlp_5m+dlmisp_5m
+ wmin=5e-007-dxwp_5m+dwmisp_5m                       wmax=1.2e-006-dxwp_5m+dwmisp_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.40604072+dvthp_5m+vthmisp_5m
+ lvth0=9.2360271e-009+dlvthp_5m                      wvth0=4.393794e-009+dwvthp_5m
+ pvth0=1.7448608e-014+dpvthp_5m                      k1=0.6596
+ k2=0.043405122+dk2p_5m    lk2=1.8431848e-009        wk2=-9.5522261e-010+dwk2p_5m
+ pk2=-3.6045268e-015       k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-1.810818e-005        lcit=4.9807311e-010
+ wcit=1.0043262e-010       pcit=-1.4795788e-016      voff=-0.13031129
+ lvoff=1.7149314e-008      wvoff=7.4541221e-010      pvoff=-7.1453517e-015
+ nfactor=0.5               eta0=0.0085927691         leta0=3.0324901e-013
+ weta0=2.4449523e-008      peta0=-2.1026401e-019     etab=-0.061
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.013689361+du0p_5m    lu0=-5.8420679e-010+dlu0p_5m
+ wu0=-4.062868e-010+dwu0p_5m                         pu0=9.4053093e-017+dpu0p_5m
+ ua=2.3699152e-009         lua=1.8597164e-016        wua=-4.6515814e-016
+ pua=6.6183099e-023        ub=-1.6971502e-019        lub=3.7893927e-025
+ wub=1.4525068e-025        pub=-2.6881853e-031       uc=-6.130322e-011
+ luc=9.3796112e-018        wuc=-1.7158091e-017       puc=3.8147798e-025
+ vsat=85000                a0=1.2376316              la0=-5.1252895e-007
+ wa0=5.5262865e-009        pa0=1.1884829e-013        ags=0.12335212
+ lags=8.2169902e-008       wags=-7.6877417e-009      pags=-6.7468012e-015
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.0091736537         lketa=-4.9917525e-008
+ wketa=-1.5404978e-009     pketa=1.467713e-014       dwg=0
+ dwb=0                     pclm=0.53002153           lpclm=-3.4664656e-007
+ wpclm=-1.4323057e-007     ppclm=2.8105289e-013      pdiblc1=0
+ pdiblc2=-7.2383813e-005   lpdiblc2=1.493215e-009    wpdiblc2=5.0996379e-011
+ ppdiblc2=-5.993525e-016   pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=6.7
+ beta0=37.6                agidl=5.5721525e-013      lagidl=2.3836607e-018
+ wagidl=1.3380787e-017     pagidl=-1.0198806e-023    bgidl=1.0862067e+009
+ lbgidl=-18.636266         wbgidl=21.048039          pbgidl=-2.1426904e-005
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5m
+ cgdo=cgop_5m              cgbo=0                    cgdl=cglp_5m
+ cgsl=cglp_5m              clc=1e-007                cle=0.6
+ cf=cfp_5m                 ckappas=0.6               ckappad=0.6
+ acde=1                    moin=23.25                noff=2.4
+ voffcv=-0.028             tvoff=0.0037384359        ltvoff=-6.3678812e-010
+ wtvoff=-1.8460889e-010    ptvoff=5.7333698e-016     kt1=-0.27594922
+ lkt1=-4.3655984e-008      wkt1=-1.143766e-008       pkt1=1.3285862e-014
+ kt1l=0                    kt2=-0.039351733          lkt2=-1.9960891e-009
+ wkt2=-6.2424987e-010      pkt2=9.3792265e-016       ute=-1.2723222
+ lute=-1.2256494e-007      wute=-4.3013646e-009      pute=2.4481439e-014
+ ua1=-4.4379697e-010       lua1=-9.1148102e-016      wua1=-1.8053936e-016
+ pua1=2.9534083e-022       ub1=-1.7669298e-018       lub1=-3.3653408e-025
+ wub1=1.010512e-024        pub1=-3.62415e-031        uc1=5.0818338e-011
+ luc1=-1.7695303e-017      wuc1=1.2496821e-018       puc1=-1.2269404e-023
+ prt=0                     at=159802.38              lat=-0.19817673
+ wat=-0.0043549264         pat=1.3207581e-008        fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lvsat=0+dlvsatp_5m
+ pvsat=0+dpvsatp_5m        rshg=8.41                 minr=1e-3
 
     9: type=p 
+ lmin=8e-07                lmax=1.2e-006-dxlp_5m+dlmisp_5m
+ wmin=5e-007-dxwp_5m+dwmisp_5m                       wmax=1.2e-006-dxwp_5m+dwmisp_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.41442122+dvthp_5m+vthmisp_5m
+ lvth0=1.776737e-008+dlvthp_5m                       wvth0=1.8028975e-008+dwvthp_5m
+ pvth0=3.5679946e-015+dpvthp_5m                      k1=0.6596
+ k2=0.044778706+dk2p_5m    lk2=4.4487668e-010        wk2=-3.4063956e-009+dwk2p_5m
+ pk2=-1.1092327e-015       k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0003929457          lcit=7.9620262e-011
+ wcit=-1.4425554e-011      pcit=-3.1032249e-017      voff=-0.11208335
+ lvoff=-1.4067282e-009     wvoff=-1.3516603e-008     pvoff=7.3733795e-015
+ nfactor=0.5               eta0=0.008593067          weta0=2.4449317e-008
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.014066406+du0p_5m
+ lu0=-9.6803905e-010+dlu0p_5m                        wu0=-7.9886718e-010+dwu0p_5m
+ pu0=4.9369992e-016+dpu0p_5m                         ua=2.701159e-009
+ lua=-1.5123455e-016       wua=-7.4460198e-016       pua=3.5065693e-022
+ ub=-8.1991019e-020        lub=2.8963623e-025        wub=3.4875176e-025
+ pub=-4.7598263e-031       uc=-7.3262799e-011        luc=2.1554462e-017
+ wuc=-1.051803e-017        puc=-6.3781041e-024       vsat=79371.786
+ lvsat=0.0057295221+dlvsatp_5m                       wvsat=0.0068101393
+ pvsat=-6.9327218e-009+dpvsatp_5m                    a0=1.0540141
+ la0=-3.2560641e-007       wa0=1.7498241e-007        pa0=-5.3658047e-014
+ ags=0.25423392            lags=-5.1067773e-008      wags=-7.4569099e-008
+ pags=6.1338421e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.06470575
+ lketa=2.5291707e-008      wketa=3.6754827e-008      pketa=-2.4307511e-014
+ dwg=0                     dwb=0                     pclm=-0.56720805
+ lpclm=7.7033316e-007      wpclm=5.4241461e-007      ppclm=-4.169339e-013
+ pdiblc1=0                 pdiblc2=0.0020612061      lpdiblc2=-6.7877954e-010
+ wpdiblc2=-2.1858121e-009  ppdiblc2=1.6777185e-015   pdiblcb=-0.2
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=4.11e+008          pscbe2=1e-006             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.49                  rdsw=1000                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=6.7                beta0=37.6                agidl=3.6503933e-012
+ lagidl=-7.6519458e-019    wagidl=5.8643587e-018     pagidl=-2.5470821e-024
+ bgidl=1.0679e+009         cgidl=150                 egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_5m              cgdo=cgop_5m              cgbo=0
+ cgdl=cglp_5m              cgsl=cglp_5m              clc=1e-007
+ cle=0.6                   cf=cfp_5m                 ckappas=0.6
+ ckappad=0.6               acde=1                    moin=23.25
+ noff=2.4                  voffcv=-0.028             tvoff=0.0005988481
+ ltvoff=2.5593123e-009     wtvoff=2.9536492e-009     ptvoff=-2.6214098e-015
+ kt1=-0.28026472           lkt1=-3.9262806e-008      wkt1=1.1334786e-008
+ pkt1=-9.8964881e-015      kt1l=0                    kt2=-0.034688933
+ lkt2=-6.7428199e-009      wkt2=-3.0045799e-009      pkt2=3.3610986e-015
+ ute=-1.4029896            lute=1.0454421e-008       wute=1.1983505e-008
+ pute=7.9034415e-015       ua1=-4.9770894e-010       lua1=-8.5659863e-016
+ wua1=-4.3803762e-016      pua1=5.5747405e-022       ub1=-5.9428203e-018
+ lub1=3.9145225e-024       wub1=3.0428617e-024       pub1=-2.431347e-030
+ uc1=-8.3902783e-011       luc1=1.194508e-016        wuc1=8.2369456e-017
+ puc1=-9.4849334e-023      prt=0                     at=59865.75
+ lat=-0.096441239          wat=-0.047585506          pat=5.7216311e-008
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=4.2e+40              noib=1.6e+24
+ noic=1.5e+9               lintnoi=-1.0e-7           jss=7.434e-7
+ jsd=7.434e-7              jsws=1.117e-11            jswd=1.117e-11
+ jswgs=1.8e-011            jswgd=1.8e-011            njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.7
+ bvd=9.7                   xjbvs=1                   xjbvd=1
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=25.9
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1
+ vtsswgs=3                 vtsswgd=3                 pbs=0.818
+ pbd=0.818                 cjs=cjp_5m                cjd=cjp_5m
+ mjs=0.359                 mjd=0.359                 pbsws=0.721
+ pbswd=0.721               cjsws=cjswp_5m            cjswd=cjswp_5m
+ mjsws=0.366               mjswd=0.366               pbswgs=0.721
+ pbswgd=0.721              cjswgs=cjswgp_5m          cjswgd=cjswgp_5m
+ mjswgs=0.366              mjswgd=0.366              tpb=1.41e-03
+ tcj=7.56e-04              tpbsw=8.25e-04            tcjsw=6.43e-04
+ tpbswg=8.25e-4            tcjswg=6.43e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ rshg=8.41                 minr=1e-3
 
     10: type=p 
+ lmin=1e-005-dxlp_5m+dlmisp_5m                       lmax=900.01e-6
+ wmin=2.2e-07              wmax=5e-007-dxwp_5m+dwmisp_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.38560714+dvthp_5m+vthmisp_5m
+ wvth0=-3.7703571e-009+dwvthp_5m                     k1=0.6596
+ k2=0.049214286+dk2p_5m    wk2=-4.1892857e-009+dwk2p_5m
+ k3=0                      k3b=0.14                  w0=0
+ dvt0=1.3                  dvt1=0.26936              dvt2=0.03
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.195               voffl=0
+ dvtp0=4.5e-007            dvtp1=0.1                 lpe0=7e-008
+ lpeb=2.5e-008             xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0002                voff=-0.14124571          wvoff=6.4850143e-009
+ nfactor=0.5               eta0=0.056309571          weta0=1.1394857e-010
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.013612643+du0p_5m
+ wu0=-3.8792786e-010+dwu0p_5m                        ua=2.019e-009
+ wua=-2.6979e-016          ub=1.2643275e-019         wub=-1.3480703e-026
+ uc=-8.2985893e-011        wuc=-5.5738446e-018       vsat=89107.143
+ wvsat=-0.0020946429       a0=1.2840714              wa0=-3.2676429e-008
+ ags=0.13608214            wags=-1.0598893e-008      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.0014137321         wketa=1.3189966e-009      dwg=0
+ dwb=0                     pclm=0.31928571           wpclm=-2.5135714e-008
+ pdiblc1=0                 pdiblc2=-1.3928571e-005   wpdiblc2=3.7703571e-011
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=6.7                beta0=37.6
+ agidl=-3.75e-012          wagidl=1.46625e-017       bgidl=1.0774357e+009
+ wbgidl=22.370786          cgidl=150                 egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_5m              cgdo=cgop_5m              cgbo=0
+ cgdl=cglp_5m              cgsl=cglp_5m              clc=1e-007
+ cle=0.6                   cf=cfp_5m                 ckappas=0.6
+ ckappad=0.6               acde=1                    moin=23.25
+ noff=2.4                  voffcv=-0.028             tvoff=0.0026151041
+ ltvoff=0                  wtvoff=4.1360864e-010     ptvoff=0
+ kt1=-0.3102967            wkt1=5.1650416e-009       kt1l=0
+ kt2=-0.045769002          wkt2=2.6404004e-009       ute=-1.3251924
+ wute=1.878924e-008        ua1=-1.5202063e-009       wua1=3.5116369e-016
+ ub1=6.8139714e-019        wub1=-2.9252944e-025      uc1=4.9016e-011
+ prt=0                     at=142378.79              wat=-0.0044180207
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=4.2e+40              noib=1.6e+24
+ noic=1.5e+9               lintnoi=-1.0e-7           jss=7.434e-7
+ jsd=7.434e-7              jsws=1.117e-11            jswd=1.117e-11
+ jswgs=1.8e-011            jswgd=1.8e-011            njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.7
+ bvd=9.7                   xjbvs=1                   xjbvd=1
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=25.9
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1
+ vtsswgs=3                 vtsswgd=3                 pbs=0.818
+ pbd=0.818                 cjs=cjp_5m                cjd=cjp_5m
+ mjs=0.359                 mjd=0.359                 pbsws=0.721
+ pbswd=0.721               cjsws=cjswp_5m            cjswd=cjswp_5m
+ mjsws=0.366               mjswd=0.366               pbswgs=0.721
+ pbswgd=0.721              cjswgs=cjswgp_5m          cjswgd=cjswgp_5m
+ mjswgs=0.366              mjswgd=0.366              tpb=1.41e-03
+ tcj=7.56e-04              tpbsw=8.25e-04            tcjsw=6.43e-04
+ tpbswg=8.25e-4            tcjswg=6.43e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ pu0=0+dpu0p_5m            lu0=0+dlu0p_5m            lvth0=0+dlvthp_5m
+ pvth0=0+dpvthp_5m         lvsat=0+dlvsatp_5m        pvsat=0+dpvsatp_5m
+ rshg=8.41                 minr=1e-3
 
     11: type=p 
+ lmin=1.2e-006-dxlp_5m+dlmisp_5m                     lmax=1e-005-dxlp_5m+dlmisp_5m
+ wmin=2.2e-07              wmax=5e-007-dxwp_5m+dwmisp_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.38939167+dvthp_5m+vthmisp_5m
+ lvth0=3.7156514e-008+dlvthp_5m                      wvth0=-4.0972221e-009+dwvthp_5m
+ pvth0=3.2091602e-015+dpvthp_5m                      k1=0.6596
+ k2=0.049461349+dk2p_5m    lk2=-2.4256667e-009       wk2=-4.0438984e-009+dwk2p_5m
+ pk2=-1.4274126e-015       k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00017092191         lcit=2.8548871e-010
+ wcit=4.0272793e-012       pcit=-3.9539829e-017      voff=-0.14300633
+ lvoff=1.7285706e-008      wvoff=7.21988e-009        pvoff=-7.2149115e-015
+ nfactor=0.5               eta0=0.056309592          leta0=-1.9859646e-013
+ weta0=1.1394392e-010      peta0=4.5677187e-020      etab=-0.061
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.013522799+du0p_5m    lu0=8.8208307e-010+dlu0p_5m
+ wu0=-3.2134049e-010+dwu0p_5m                        pu0=-6.5375474e-016+dpu0p_5m
+ ua=1.9688809e-009         lua=4.9206974e-016        wua=-2.6063061e-016
+ pua=-8.9926933e-023       ub=1.3371435e-019         lub=-7.1490792e-026
+ wub=-9.4983032e-027       pub=-3.9099196e-032       uc=-8.5414e-011
+ luc=2.3839159e-017        wuc=-4.8615925e-018       puc=-6.9928913e-024
+ vsat=89278.187            lvsat=-0.0016793083+dlvsatp_5m
+ wvsat=-0.0021818752       pvsat=8.5644725e-010+dpvsatp_5m
+ a0=1.3129269              la0=-2.8330303e-007       wa0=-3.2874337e-008
+ pa0=1.9430647e-015        ags=0.12424252            lags=1.162414e-007
+ wags=-8.1418482e-009      pags=-2.4123264e-014      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.0040194505         lketa=-2.5582942e-008     wketa=1.0881459e-009
+ pketa=2.2664922e-015      dwg=0                     dwb=0
+ pclm=0.29751274           lpclm=2.1376703e-007      wpclm=-2.465109e-008
+ ppclm=-4.7580403e-015     pdiblc1=0                 pdiblc2=-3.0165349e-005
+ lpdiblc2=1.5941269e-010   wpdiblc2=2.9464962e-011   ppdiblc2=8.0886666e-017
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=6.7                beta0=37.6
+ agidl=-1.9076286e-012     lagidl=-1.8088403e-017    wagidl=1.4637857e-017
+ pagidl=2.4194678e-025     bgidl=1.0785388e+009      lbgidl=-10.830322
+ wbgidl=24.958679          pbgidl=-2.5407935e-005    cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5m              cgdo=cgop_5m
+ cgbo=0                    cgdl=cglp_5m              cgsl=cglp_5m
+ clc=1e-007                cle=0.6                   cf=cfp_5m
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=23.25                noff=2.4                  voffcv=-0.028
+ tvoff=0.00239464          ltvoff=2.1645159e-009     wtvoff=5.00727e-010
+ ptvoff=-8.5532806e-016    kt1=-0.31013313           lkt1=-1.6059631e-009
+ wkt1=5.9961323e-009       pkt1=-8.1596489e-015      kt1l=0
+ kt2=-0.046081103          lkt2=3.0642102e-009       wkt2=2.8077288e-009
+ pkt2=-1.64283e-015        ute=-1.3169376            lute=-8.1045461e-008
+ wute=1.845246e-008        pute=3.3065049e-015       ua1=-1.5378773e-009
+ lua1=1.7349385e-016       wua1=3.7744158e-016       pua1=-2.5799636e-022
+ ub1=9.6978277e-019        lub1=-2.8313701e-024      wub1=-3.8521139e-025
+ pub1=9.0995137e-031       uc1=5.4954997e-011        luc1=-5.8309072e-017
+ wuc1=-8.6001404e-019      puc1=8.4436178e-024       prt=0
+ at=161096.8               lat=-0.18377345           wat=-0.005015078
+ pat=5.861909e-009         fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.13                   noia=4.2e+40
+ noib=1.6e+24              noic=1.5e+9               lintnoi=-1.0e-7
+ jss=7.434e-7              jsd=7.434e-7              jsws=1.117e-11
+ jswd=1.117e-11            jswgs=1.8e-011            jswgd=1.8e-011
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.7                   bvd=9.7                   xjbvs=1
+ xjbvd=1                   jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=25.9              xtsswgs=0.48              xtsswgd=0.48
+ tnjtsswg=1                vtsswgs=3                 vtsswgd=3
+ pbs=0.818                 pbd=0.818                 cjs=cjp_5m
+ cjd=cjp_5m                mjs=0.359                 mjd=0.359
+ pbsws=0.721               pbswd=0.721               cjsws=cjswp_5m
+ cjswd=cjswp_5m            mjsws=0.366               mjswd=0.366
+ pbswgs=0.721              pbswgd=0.721              cjswgs=cjswgp_5m
+ cjswgd=cjswgp_5m          mjswgs=0.366              mjswgd=0.366
+ tpb=1.41e-03              tcj=7.56e-04              tpbsw=8.25e-04
+ tcjsw=6.43e-04            tpbswg=8.25e-4            tcjswg=6.43e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   rshg=8.41                 minr=1e-3
 
     12: type=p 
+ lmin=8e-07                lmax=1.2e-006-dxlp_5m+dlmisp_5m
+ wmin=2.2e-07              wmax=5e-007-dxwp_5m+dwmisp_5m
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  geomod=0                  diomod=1
+ rdsmod=0                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxp_5m+toxmisp_5m
+ toxm=toxp_5m+toxmisp_5m   dtox=1.365e-010           epsrox=3.9
+ wint=0                    lint=7.6e-008             ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3e-08+dxlp_5m+dlmisp_5m                         xw=1e-08+dxwp_5m+dwmisp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.38768115+dvthp_5m+vthmisp_5m
+ lvth0=3.5415199e-008+dlvthp_5m                      wvth0=4.391539e-009+dwvthp_5m
+ pvth0=-5.4323986e-015+dpvthp_5m                     k1=0.6596
+ k2=0.054742874+dk2p_5m    lk2=-7.8022595e-009       wk2=-8.4881217e-009+dwk2p_5m
+ pk2=3.0968067e-015        k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00080020686         lcit=-3.5512338e-010
+ wcit=-2.2212875e-010      pcit=1.9068701e-016       voff=-0.13190159
+ lvoff=5.9810768e-009      wvoff=-3.409305e-009      pvoff=3.6055989e-015
+ nfactor=0.5               eta0=0.056309397          weta0=1.1398879e-010
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.014028479+du0p_5m
+ lu0=3.6730169e-010+dlu0p_5m                         wu0=-7.7952406e-010+dwu0p_5m
+ pu0=-1.8732386e-016+dpu0p_5m                        ua=1.4710648e-009
+ lua=9.9884649e-016        wua=-1.1725392e-016       pua=-2.358844e-022
+ ub=1.4868333e-018         lub=-1.4489658e-024       wub=-4.5134862e-025
+ pub=4.1070443e-031        uc=-7.7906714e-011        luc=1.6196741e-017
+ wuc=-8.1496328e-018       puc=-3.6456663e-024       vsat=99287.804
+ lvsat=-0.011869098+dlvsatp_5m                       wvsat=-0.0033470298
+ pvsat=2.0425746e-009+dpvsatp_5m                     a0=1.6785522
+ la0=-6.555096e-007        wa0=-1.4353202e-007       pa0=1.1459258e-013
+ ags=0.11460786            lags=1.2604949e-007       wags=-3.3598071e-009
+ pags=-2.8991382e-014      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.0035721333
+ lketa=-1.785471e-008      wketa=5.5766821e-009      pketa=-2.3028377e-015
+ dwg=0                     dwb=0                     pclm=0.61730536
+ lpclm=-1.1178185e-007     wpclm=-6.1687232e-008     ppclm=3.2944752e-014
+ pdiblc1=0                 pdiblc2=-0.0027682391     lpdiblc2=2.9467718e-009
+ wpdiblc2=2.7720499e-010   ppdiblc2=-1.7131269e-016  pdiblcb=-0.2
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=4.11e+008          pscbe2=1e-006             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.49                  rdsw=1000                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=6.7                beta0=37.6                agidl=-4.9471197e-011
+ lagidl=3.033131e-017      wagidl=3.295637e-017      pagidl=-1.84063e-023
+ bgidl=1.0679e+009         cgidl=150                 egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_5m              cgdo=cgop_5m              cgbo=0
+ cgdl=cglp_5m              cgsl=cglp_5m              clc=1e-007
+ cle=0.6                   cf=cfp_5m                 ckappas=0.6
+ ckappad=0.6               acde=1                    moin=23.25
+ noff=2.4                  voffcv=-0.028             tvoff=0.0085801321
+ ltvoff=-4.1323151e-009    wtvoff=-1.1168056e-009    ptvoff=7.9132017e-016
+ kt1=-0.22161763           lkt1=-9.1714747e-008      wkt1=-1.8575234e-008
+ pkt1=1.6854002e-014       kt1l=0                    kt2=-0.044062373
+ lkt2=1.0091434e-009       wkt2=1.7758748e-009       pkt2=-5.9240265e-016
+ ute=-1.1965222            lute=-2.0362834e-007      wute=-9.3314873e-008
+ pute=1.1708565e-013       ua1=8.626024e-010         lua1=-2.2701945e-015
+ wua1=-1.1317964e-015      pua1=1.2784079e-021       ub1=-5.4182809e-018
+ lub1=3.6716787e-024       wub1=2.7753466e-024       pub1=-2.3074967e-030
+ uc1=4.7534354e-011        luc1=-5.0754857e-017      wuc1=1.5336517e-017
+ puc1=-8.0444503e-024      prt=0                     at=-77227.446
+ lat=0.058840629           wat=0.022332024           pat=-2.1977441e-008
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=4.2e+40              noib=1.6e+24
+ noic=1.5e+9               lintnoi=-1.0e-7           jss=7.434e-7
+ jsd=7.434e-7              jsws=1.117e-11            jswd=1.117e-11
+ jswgs=1.8e-011            jswgd=1.8e-011            njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.7
+ bvd=9.7                   xjbvs=1                   xjbvd=1
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=25.9
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1
+ vtsswgs=3                 vtsswgd=3                 pbs=0.818
+ pbd=0.818                 cjs=cjp_5m                cjd=cjp_5m
+ mjs=0.359                 mjd=0.359                 pbsws=0.721
+ pbswd=0.721               cjsws=cjswp_5m            cjswd=cjswp_5m
+ mjsws=0.366               mjswd=0.366               pbswgs=0.721
+ pbswgd=0.721              cjswgs=cjswgp_5m          cjswgd=cjswgp_5m
+ mjswgs=0.366              mjswgd=0.366              tpb=1.41e-03
+ tcj=7.56e-04              tpbsw=8.25e-04            tcjsw=6.43e-04
+ tpbswg=8.25e-4            tcjswg=6.43e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ rshg=8.41                 minr=1e-3
 
     } 
ends mepch5_mac
// 
model mepch5 bsim4  { 
     1: type=p 
+ lmin=1e-005-dxlp_5m       lmax=900.01e-6            wmin=1e-005-dxwp_5m
+ wmax=900.01e-6            version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.40989+dvthp_5m
+ k1=0.6596                 k2=0.045107+dk2p_5m       k3=0
+ k3b=0.14                  w0=0                      dvt0=1.3
+ dvt1=0.26936              dvt2=0.03                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56029329
+ minv=-0.195               voffl=0                   dvtp0=4.5e-007
+ dvtp1=0.1                 lpe0=7e-008               lpeb=2.5e-008
+ xj=1.5e-007               ngate=1.5e+021            ndep=1.424026e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0004301
+ voff=-0.12776             nfactor=0.5               eta0=0.014269
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.01614+du0p_5m
+ ua=2.465e-009             ub=6.4203e-020            uc=-4.5033e-011
+ vsat=85000                a0=1.25                   ags=0.1356
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0032943           dwg=0
+ dwb=0                     pclm=0.3                  pdiblc1=0
+ pdiblc2=0.00021           pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=6.7
+ beta0=37.6                agidl=2.6361e-012         bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5m
+ cgdo=cgop_5m              cgbo=0                    cgdl=cglp_5m
+ cgsl=cglp_5m              clc=1e-007                cle=0.6
+ cf=cfp_5m                 ckappas=0.6               ckappad=0.6
+ acde=1                    moin=23.25                noff=2.4
+ voffcv=-0.028             tvoff=0.0041635686        ltvoff=0
+ wtvoff=0                  ptvoff=0                  kt1=-0.28526
+ kt1l=0                    kt2=-0.038751             ute=-1.3256
+ ua1=-6.761e-010           ub1=-1.342e-018           uc1=-8.4585e-012
+ prt=0                     at=139000                 fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   pu0=0+dpu0p_5m
+ wu0=0+dwu0p_5m            lu0=0+dlu0p_5m            lvth0=0+dlvthp_5m
+ wvth0=0+dwvthp_5m         pvth0=0+dpvthp_5m         wk2=0+dwk2p_5m
+ lvsat=0+dlvsatp_5m        pvsat=0+dpvsatp_5m        rshg=8.41
+ minr=1e-3
 
     2: type=p 
+ lmin=1.2e-006-dxlp_5m     lmax=1e-005-dxlp_5m       wmin=1e-005-dxwp_5m
+ wmax=900.01e-6            version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.408436+dvthp_5m
+ lvth0=-1.4275419e-008+dlvthp_5m                     k1=0.6596
+ k2=0.04487788+dk2p_5m     lk2=2.2494978e-009        k3=0
+ k3b=0.14                  w0=0                      dvt0=1.3
+ dvt1=0.26936              dvt2=0.03                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56029329
+ minv=-0.195               voffl=0                   dvtp0=4.5e-007
+ dvtp1=0.1                 lpe0=7e-008               lpeb=2.5e-008
+ xj=1.5e-007               ngate=1.5e+021            ndep=1.424026e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00041484764
+ lcit=1.4974768e-010       voff=-0.12999046          lvoff=2.1898667e-008
+ nfactor=0.5               eta0=0.014269045          leta0=-4.4181223e-013
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.016224566+du0p_5m
+ lu0=-8.3026513e-010+dlu0p_5m                        ua=2.4593316e-009
+ lua=5.5652441e-017        ub=5.2635165e-020         lub=1.13573e-025
+ uc=-4.594839e-011         luc=8.9873013e-018        vsat=85000
+ a0=1.3059788              la0=-5.4959983e-007       ags=0.13098226
+ lags=4.5336999e-008       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.00068038834
+ lketa=-2.5663385e-008     dwg=0                     dwb=0
+ pclm=0.2900398            lpclm=9.7789288e-008      pdiblc1=0
+ pdiblc2=0.00013943409     lpdiblc2=6.928161e-010    pdiblcb=-0.2
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=4.11e+008          pscbe2=1e-006             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.49                  rdsw=1000                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=6.7                beta0=37.6                agidl=2.6009212e-012
+ lagidl=3.4538586e-019     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5m              cgdo=cgop_5m
+ cgbo=0                    cgdl=cglp_5m              cgsl=cglp_5m
+ clc=1e-007                cle=0.6                   cf=cfp_5m
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=23.25                noff=2.4                  voffcv=-0.028
+ tvoff=0.0040568059        ltvoff=1.0481966e-009     wtvoff=0
+ ptvoff=0                  kt1=-0.28142283           lkt1=-3.7673295e-008
+ kt1l=0                    kt2=-0.038370638          lkt2=-3.7343923e-009
+ ute=-1.3153853            lute=-1.0028797e-007      ua1=-6.0334771e-010
+ lua1=-7.1428204e-016      ub1=-1.2868429e-018       lub1=-5.4153232e-025
+ uc1=-1.085456e-011        luc1=2.3524515e-017       prt=0
+ at=157410.53              lat=-0.18075458           fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   pu0=0+dpu0p_5m
+ wu0=0+dwu0p_5m            wvth0=0+dwvthp_5m         pvth0=0+dpvthp_5m
+ wk2=0+dwk2p_5m            lvsat=0+dlvsatp_5m        pvsat=0+dpvsatp_5m
+ rshg=8.41                 minr=1e-3
 
     3: type=p 
+ lmin=8e-07                lmax=1.2e-006-dxlp_5m     wmin=1e-005-dxwp_5m
+ wmax=900.01e-6            version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.42780316+dvthp_5m
+ lvth0=5.4403498e-009+dlvthp_5m                      k1=0.6596
+ k2=0.046295948+dk2p_5m    lk2=8.059047e-010         k3=0
+ k3b=0.14                  w0=0                      dvt0=1.3
+ dvt1=0.26936              dvt2=0.03                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56029329
+ minv=-0.195               voffl=0                   dvtp0=4.5e-007
+ dvtp1=0.1                 lpe0=7e-008               lpeb=2.5e-008
+ xj=1.5e-007               ngate=1.5e+021            ndep=1.424026e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00060000456
+ lcit=-3.8742069e-011      voff=-0.10651531          lvoff=-1.9990415e-009
+ nfactor=0.5               eta0=0.014268613          leta0=-1.57281e-015
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.015913122+du0p_5m
+ lu0=-5.1321577e-010+dlu0p_5m                        ua=2.47383e-009
+ lua=4.089306e-017         ub=9.86995e-021           lub=1.5710799e-025
+ uc=-5.622547e-011         luc=1.9449369e-017        vsat=85000
+ a0=1.3351091              la0=-5.7925452e-007       ags=0.32463736
+ lags=-1.5180389e-007      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.019862955
+ lketa=-6.1355318e-009     dwg=0                     dwb=0
+ pclm=0.25647449           lpclm=1.3195878e-007      pdiblc1=0
+ pdiblc2=-0.00084860016    lpdiblc2=1.698635e-009    pdiblcb=-0.2
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=4.11e+008          pscbe2=1e-006             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.49                  rdsw=1000                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=6.7                beta0=37.6                agidl=3.620309e-012
+ lagidl=-6.9235096e-019    bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5m              cgdo=cgop_5m
+ cgbo=0                    cgdl=cglp_5m              cgsl=cglp_5m
+ clc=1e-007                cle=0.6                   cf=cfp_5m
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=23.25                noff=2.4                  voffcv=-0.028
+ tvoff=0.0052725593        ltvoff=-1.894404e-010     wtvoff=0
+ ptvoff=0                  kt1=-0.2996843            lkt1=-1.9083124e-008
+ kt1l=0                    kt2=-0.039481779          lkt2=-2.6032506e-009
+ ute=-1.3613699            lute=-5.3475697e-008      ua1=3.1513455e-012
+ lua1=-1.3316981e-015      ub1=-4.5528475e-018       lub1=2.7832604e-024
+ uc1=-4.7015288e-011       luc1=6.0336136e-017       prt=0
+ at=7385.4476              lat=-0.028029049          fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   pu0=0+dpu0p_5m
+ wu0=0+dwu0p_5m            wvth0=0+dwvthp_5m         pvth0=0+dpvthp_5m
+ wk2=0+dwk2p_5m            lvsat=0+dlvsatp_5m        pvsat=0+dpvsatp_5m
+ rshg=8.41                 minr=1e-3
 
     4: type=p 
+ lmin=1e-005-dxlp_5m       lmax=900.01e-6            wmin=1.2e-006-dxwp_5m
+ wmax=1e-005-dxwp_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.41124988+dvthp_5m
+ wvth0=1.3612349e-008+dwvthp_5m                      k1=0.6596
+ k2=0.045465463+dk2p_5m    wk2=-3.5882096e-009+dwk2p_5m
+ k3=0                      k3b=0.14                  w0=0
+ dvt0=1.3                  dvt1=0.26936              dvt2=0.03
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.195               voffl=0
+ dvtp0=4.5e-007            dvtp1=0.1                 lpe0=7e-008
+ lpeb=2.5e-008             xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00047505288         wcit=-4.4997828e-010      voff=-0.12765138
+ wvoff=-1.0873363e-009     nfactor=0.5               eta0=0.012271125
+ weta0=1.9998729e-008      etab=-0.061               ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.016530225+du0p_5m    wu0=-3.9061523e-009+dwu0p_5m
+ ua=2.5275625e-009         wua=-6.2625063e-016       ub=7.766535e-020
+ wub=-1.3475812e-025       uc=-4.0981838e-011        wuc=-4.0552137e-017
+ vsat=85000                a0=1.256875               wa0=-6.881875e-008
+ ags=0.137085              wags=-1.486485e-008       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.004304375         wketa=1.0110851e-008      dwg=0
+ dwb=0                     pclm=0.28625              wpclm=1.376375e-007
+ pdiblc1=0                 pdiblc2=0.0002290575      wpdiblc2=-1.9076558e-010
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=6.7                beta0=37.6
+ agidl=1.4860638e-012      wagidl=1.1511863e-017     bgidl=1.0635e+009
+ wbgidl=44.044             cgidl=150                 egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_5m              cgdo=cgop_5m              cgbo=0
+ cgdl=cglp_5m              cgsl=cglp_5m              clc=1e-007
+ cle=0.6                   cf=cfp_5m                 ckappas=0.6
+ ckappad=0.6               acde=1                    moin=23.25
+ noff=2.4                  voffcv=-0.028             tvoff=0.0042452848
+ ltvoff=0                  wtvoff=-8.1797925e-010    ptvoff=0
+ kt1=-0.28478288           wkt1=-4.7760213e-009      kt1l=0
+ kt2=-0.038580363          wkt2=-1.7080814e-009      ute=-1.3310038
+ wute=5.4091538e-008       ua1=-6.78179e-010         wua1=2.081079e-017
+ ub1=-1.3894953e-018       wub1=4.7542745e-025       uc1=-1.6361244e-011
+ wuc1=7.9106469e-017       prt=0                     at=139257.13
+ wat=-0.0025738213         fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.13                   noia=4.2e+40
+ noib=1.6e+24              noic=1.5e+9               lintnoi=-1.0e-7
+ jss=7.434e-7              jsd=7.434e-7              jsws=1.117e-11
+ jswd=1.117e-11            jswgs=1.8e-011            jswgd=1.8e-011
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.7                   bvd=9.7                   xjbvs=1
+ xjbvd=1                   jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=25.9              xtsswgs=0.48              xtsswgd=0.48
+ tnjtsswg=1                vtsswgs=3                 vtsswgd=3
+ pbs=0.818                 pbd=0.818                 cjs=cjp_5m
+ cjd=cjp_5m                mjs=0.359                 mjd=0.359
+ pbsws=0.721               pbswd=0.721               cjsws=cjswp_5m
+ cjswd=cjswp_5m            mjsws=0.366               mjswd=0.366
+ pbswgs=0.721              pbswgd=0.721              cjswgs=cjswgp_5m
+ cjswgd=cjswgp_5m          mjswgs=0.366              mjswgd=0.366
+ tpb=1.41e-03              tcj=7.56e-04              tpbsw=8.25e-04
+ tcjsw=6.43e-04            tpbswg=8.25e-4            tcjswg=6.43e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   pu0=0+dpu0p_5m            lu0=0+dlu0p_5m
+ lvth0=0+dlvthp_5m         pvth0=0+dpvthp_5m         lvsat=0+dlvsatp_5m
+ pvsat=0+dpvsatp_5m        rshg=8.41                 minr=1e-3
 
     5: type=p 
+ lmin=1.2e-006-dxlp_5m     lmax=1e-005-dxlp_5m       wmin=1.2e-006-dxwp_5m
+ wmax=1e-005-dxwp_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.40926464+dvthp_5m
+ lvth0=-1.9491039e-008+dlvthp_5m                     wvth0=8.2947323e-009+dwvthp_5m
+ pvth0=5.2208358e-014+dpvthp_5m                      k1=0.6596
+ k2=0.045188933+dk2p_5m    lk2=2.7149711e-009        wk2=-3.1136335e-009+dwk2p_5m
+ pk2=-4.6593882e-015       k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00046296627         lcit=1.1866633e-010
+ wcit=-4.8166746e-010      pcit=3.1112434e-016       voff=-0.13003105
+ lvoff=2.3363675e-008      wvoff=4.0632123e-010      pvoff=-1.4664729e-014
+ nfactor=0.5               eta0=0.012271178          leta0=-5.2036452e-013
+ weta0=1.9998649e-008      peta0=7.8630836e-019      etab=-0.061
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.016619325+du0p_5m    lu0=-8.74786e-010+dlu0p_5m
+ wu0=-3.9515438e-009+dwu0p_5m                        pu0=4.4565394e-016+dpu0p_5m
+ ua=2.5244852e-009         lua=3.0212745e-017        wua=-6.5218782e-016
+ pua=2.5465136e-022        ub=6.6702557e-020         lub=1.076327e-025
+ wub=-1.4081459e-025       pub=5.946242e-032         uc=-4.1887318e-011
+ luc=8.8900089e-018        wuc=-4.0651332e-017       puc=9.7389684e-025
+ vsat=85000                a0=1.3147486              la0=-5.6820257e-007
+ wa0=-8.7785277e-008       pa0=1.8621336e-013        ags=0.13290501
+ lags=4.1039157e-008       wags=-1.924674e-008       pags=4.30214e-014
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0018602626        lketa=-2.3996296e-008
+ wketa=1.1810541e-008      pketa=-1.6687558e-014     dwg=0
+ dwb=0                     pclm=0.27331851           lpclm=1.2696139e-007
+ wpclm=1.6738009e-007      ppclm=-2.9201273e-013     pdiblc1=0
+ pdiblc2=0.00016276401     lpdiblc2=6.5086949e-010   wpdiblc2=-2.3353249e-010
+ ppdiblc2=4.1988554e-016   pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=6.7
+ beta0=37.6                agidl=1.3613868e-012      lagidl=1.2240783e-018
+ wagidl=1.2407739e-017     pagidl=-8.7957108e-024    bgidl=1.062991e+009
+ lbgidl=4.997362           wbgidl=49.13909           pbgidl=-5.0023594e-005
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5m
+ cgdo=cgop_5m              cgbo=0                    cgdl=cglp_5m
+ cgsl=cglp_5m              clc=1e-007                cle=0.6
+ cf=cfp_5m                 ckappas=0.6               ckappad=0.6
+ acde=1                    moin=23.25                noff=2.4
+ voffcv=-0.028             tvoff=0.00412156          ltvoff=1.21473e-009
+ wtvoff=-6.4818907e-010    ptvoff=-1.667e-015        kt1=-0.28087572
+ lkt1=-3.8360432e-008      wkt1=-5.4765961e-009      pkt1=6.8782441e-015
+ kt1l=0                    kt2=-0.0381648            lkt2=-4.0799912e-009
+ wkt2=-2.0604387e-009      pkt2=3.4594442e-015       ute=-1.3208177
+ lute=-1.0000687e-007      wute=5.4378136e-008       pute=-2.8138271e-015
+ ua1=-6.047701e-010        lua1=-7.2072863e-016      wua1=1.4238124e-017
+ pua1=6.4530436e-023       ub1=-1.3356619e-018       lub1=-5.2853605e-025
+ wub1=4.8867787e-025       pub1=-1.3009261e-031      uc1=-1.9476593e-011
+ luc1=3.058649e-017        wuc1=8.6306548e-017       puc1=-7.0690374e-023
+ prt=0                     at=157576.53              lat=-0.1798599
+ wat=-0.0016616409         pat=-8.9557865e-009       fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lvsat=0+dlvsatp_5m
+ pvsat=0+dpvsatp_5m        rshg=8.41                 minr=1e-3
 
     6: type=p 
+ lmin=8e-07                lmax=1.2e-006-dxlp_5m     wmin=1.2e-006-dxwp_5m
+ wmax=1e-005-dxwp_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.43169192+dvthp_5m
+ lvth0=3.3399307e-009+dlvthp_5m                      wvth0=3.8926523e-008+dwvthp_5m
+ pvth0=2.1025196e-014+dpvthp_5m                      k1=0.6596
+ k2=0.046891659+dk2p_5m    lk2=9.8159522e-010        wk2=-5.9630697e-009+dwk2p_5m
+ pk2=-1.7586622e-015       k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00063011442         lcit=-5.1490498e-011
+ wcit=-3.0139971e-010      pcit=1.2761177e-016       voff=-0.10421372
+ lvoff=-2.9183686e-009     wvoff=-2.3038859e-008     pvoff=9.2024643e-015
+ nfactor=0.5               eta0=0.012270669          leta0=-1.7890714e-015
+ weta0=1.9999419e-008      peta0=2.1647764e-021      etab=-0.061
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.016257826+du0p_5m    lu0=-5.0677983e-010+dlu0p_5m
+ wu0=-3.4504851e-009+dwu0p_5m                        pu0=-6.4423745e-017+dpu0p_5m
+ ua=2.5271861e-009         lua=2.7463229e-017        wua=-5.3409475e-016
+ pua=1.3443261e-022        ub=-1.7130049e-020        lub=1.9297429e-025
+ wub=2.7026999e-025        pub=-3.5902168e-031       uc=-5.2687607e-011
+ luc=1.9884703e-017        wuc=-3.5414012e-017       puc=-4.3576948e-024
+ vsat=85000                a0=1.3538753              la0=-6.0803363e-007
+ wa0=-1.8784965e-007       pa0=2.8807889e-013        ags=0.34279159
+ lags=-1.7262538e-007      wags=-1.8172388e-007      pags=2.0842313e-013
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.017873756         lketa=-7.6945601e-009
+ wketa=-1.9911886e-008     pketa=1.5605873e-014      dwg=0
+ dwb=0                     pclm=0.30809281           lpclm=9.156115e-008
+ wpclm=-5.1669943e-007     ppclm=4.0438023e-013      pdiblc1=0
+ pdiblc2=-0.0010003108     lpdiblc2=1.8348796e-009   wpdiblc2=1.5186234e-009
+ ppdiblc2=-1.3638091e-015  pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=6.7
+ beta0=37.6                agidl=2.949768e-012       lagidl=-3.9289381e-019
+ wagidl=6.7121153e-018     pagidl=-2.9975661e-024    bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5m
+ cgdo=cgop_5m              cgbo=0                    cgdl=cglp_5m
+ cgsl=cglp_5m              clc=1e-007                cle=0.6
+ cf=cfp_5m                 ckappas=0.6               ckappad=0.6
+ acde=1                    moin=23.25                noff=2.4
+ voffcv=-0.028             tvoff=0.0055795526        ltvoff=-2.6950642e-010
+ wtvoff=-3.0730032e-009    ptvoff=8.0146082e-016     kt1=-0.30364253
+ lkt1=-1.5183817e-008      wkt1=3.962194e-008        pkt1=-3.9032065e-014
+ kt1l=0                    kt2=-0.039799366          lkt2=-2.4160029e-009
+ wkt2=3.1790447e-009       pkt2=-1.87435e-015        ute=-1.3570089
+ lute=-6.3164207e-008      wute=-4.365311e-008       pute=9.6981981e-014
+ ua1=1.2179664e-010        lua1=-1.4603736e-015      wua1=-1.1876394e-015
+ pua1=1.2880417e-021       ub1=-4.707506e-018        lub1=2.9040013e-024
+ wub1=1.5481314e-024       pub1=-1.2086163e-030      uc1=-5.1303422e-011
+ luc1=6.2986203e-017       wuc1=4.292423e-017        puc1=-2.6527174e-023
+ prt=0                     at=5576.8498              lat=-0.025124226
+ wat=0.018104064           pat=-2.9077274e-008       fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lvsat=0+dlvsatp_5m
+ pvsat=0+dpvsatp_5m        rshg=8.41                 minr=1e-3
 
     7: type=p 
+ lmin=1e-005-dxlp_5m       lmax=900.01e-6            wmin=5e-007-dxwp_5m
+ wmax=1.2e-006-dxwp_5m     version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.4051+dvthp_5m
+ wvth0=6.171e-009+dwvthp_5m                          k1=0.6596
+ k2=0.043592857+dk2p_5m    wk2=-1.3223571e-009+dwk2p_5m
+ k3=0                      k3b=0.14                  w0=0
+ dvt0=1.3                  dvt1=0.26936              dvt2=0.03
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.195               voffl=0
+ dvtp0=4.5e-007            dvtp1=0.1                 lpe0=7e-008
+ lpeb=2.5e-008             xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=3.2622429e-005        wcit=8.5362561e-011       voff=-0.12856457
+ wvoff=1.7631429e-011      nfactor=0.5               eta0=0.0085928
+ weta0=2.4449502e-008      etab=-0.061               ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.013629857+du0p_5m    wu0=-3.9670714e-010+dwu0p_5m
+ ua=2.3888571e-009         wua=-4.5841714e-016       ub=-1.3111864e-019
+ wub=1.1787051e-025        uc=-6.0347871e-011        wuc=-1.7119236e-017
+ vsat=85000                a0=1.1854286              wa0=1.7631429e-008
+ ags=0.13172143            wags=-8.3749286e-009      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.0040893671         wketa=-4.5577243e-011     dwg=0
+ dwb=0                     pclm=0.49471429           wpclm=-1.1460429e-007
+ pdiblc1=0                 pdiblc2=7.9705714e-005    wpdiblc2=-1.0049914e-011
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=6.7                beta0=37.6
+ agidl=8e-013              wagidl=1.2342e-017        bgidl=1.0843086e+009
+ wbgidl=18.865629          cgidl=150                 egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_5m              cgdo=cgop_5m              cgbo=0
+ cgdl=cglp_5m              cgsl=cglp_5m              clc=1e-007
+ cle=0.6                   cf=cfp_5m                 ckappas=0.6
+ ckappad=0.6               acde=1                    moin=23.25
+ noff=2.4                  voffcv=-0.028             tvoff=0.0036735767
+ ltvoff=0                  wtvoff=-1.2621238e-010    ptvoff=0
+ kt1=-0.28039575           wkt1=-1.0084445e-008      kt1l=0
+ kt2=-0.039555042          wkt2=-5.2871894e-010      ute=-1.2848059
+ wute=-1.8078385e-009      ua1=-5.3663471e-010       wua1=-1.504578e-016
+ ub1=-1.801207e-018        wub1=9.7359867e-025       uc1=4.9016005e-011
+ wuc1=-2.6447143e-024      prt=0                     at=139617.34
+ wat=-0.0030096849         fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.13                   noia=4.2e+40
+ noib=1.6e+24              noic=1.5e+9               lintnoi=-1.0e-7
+ jss=7.434e-7              jsd=7.434e-7              jsws=1.117e-11
+ jswd=1.117e-11            jswgs=1.8e-011            jswgd=1.8e-011
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.7                   bvd=9.7                   xjbvs=1
+ xjbvd=1                   jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=25.9              xtsswgs=0.48              xtsswgd=0.48
+ tnjtsswg=1                vtsswgs=3                 vtsswgd=3
+ pbs=0.818                 pbd=0.818                 cjs=cjp_5m
+ cjd=cjp_5m                mjs=0.359                 mjd=0.359
+ pbsws=0.721               pbswd=0.721               cjsws=cjswp_5m
+ cjswd=cjswp_5m            mjsws=0.366               mjswd=0.366
+ pbswgs=0.721              pbswgd=0.721              cjswgs=cjswgp_5m
+ cjswgd=cjswgp_5m          mjswgs=0.366              mjswgd=0.366
+ tpb=1.41e-03              tcj=7.56e-04              tpbsw=8.25e-04
+ tcjsw=6.43e-04            tpbswg=8.25e-4            tcjswg=6.43e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   pu0=0+dpu0p_5m            lu0=0+dlu0p_5m
+ lvth0=0+dlvthp_5m         pvth0=0+dpvthp_5m         lvsat=0+dlvsatp_5m
+ pvsat=0+dpvsatp_5m        rshg=8.41                 minr=1e-3
 
     8: type=p 
+ lmin=1.2e-006-dxlp_5m     lmax=1e-005-dxlp_5m       wmin=5e-007-dxwp_5m
+ wmax=1.2e-006-dxwp_5m     version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.40604072+dvthp_5m
+ lvth0=9.2360271e-009+dlvthp_5m                      wvth0=4.393794e-009+dwvthp_5m
+ pvth0=1.7448608e-014+dpvthp_5m                      k1=0.6596
+ k2=0.043405122+dk2p_5m    lk2=1.8431848e-009        wk2=-9.5522261e-010+dwk2p_5m
+ pk2=-3.6045268e-015       k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-1.810818e-005        lcit=4.9807311e-010
+ wcit=1.0043262e-010       pcit=-1.4795788e-016      voff=-0.13031129
+ lvoff=1.7149314e-008      wvoff=7.4541221e-010      pvoff=-7.1453517e-015
+ nfactor=0.5               eta0=0.0085927691         leta0=3.0324901e-013
+ weta0=2.4449523e-008      peta0=-2.1026401e-019     etab=-0.061
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.013689361+du0p_5m    lu0=-5.8420679e-010+dlu0p_5m
+ wu0=-4.062868e-010+dwu0p_5m                         pu0=9.4053093e-017+dpu0p_5m
+ ua=2.3699152e-009         lua=1.8597164e-016        wua=-4.6515814e-016
+ pua=6.6183099e-023        ub=-1.6971502e-019        lub=3.7893927e-025
+ wub=1.4525068e-025        pub=-2.6881853e-031       uc=-6.130322e-011
+ luc=9.3796112e-018        wuc=-1.7158091e-017       puc=3.8147798e-025
+ vsat=85000                a0=1.2376316              la0=-5.1252895e-007
+ wa0=5.5262865e-009        pa0=1.1884829e-013        ags=0.12335212
+ lags=8.2169902e-008       wags=-7.6877417e-009      pags=-6.7468012e-015
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.0091736537         lketa=-4.9917525e-008
+ wketa=-1.5404978e-009     pketa=1.467713e-014       dwg=0
+ dwb=0                     pclm=0.53002153           lpclm=-3.4664656e-007
+ wpclm=-1.4323057e-007     ppclm=2.8105289e-013      pdiblc1=0
+ pdiblc2=-7.2383813e-005   lpdiblc2=1.493215e-009    wpdiblc2=5.0996379e-011
+ ppdiblc2=-5.993525e-016   pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=6.7
+ beta0=37.6                agidl=5.5721525e-013      lagidl=2.3836607e-018
+ wagidl=1.3380787e-017     pagidl=-1.0198806e-023    bgidl=1.0862067e+009
+ lbgidl=-18.636266         wbgidl=21.048039          pbgidl=-2.1426904e-005
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5m
+ cgdo=cgop_5m              cgbo=0                    cgdl=cglp_5m
+ cgsl=cglp_5m              clc=1e-007                cle=0.6
+ cf=cfp_5m                 ckappas=0.6               ckappad=0.6
+ acde=1                    moin=23.25                noff=2.4
+ voffcv=-0.028             tvoff=0.0037384359        ltvoff=-6.3678812e-010
+ wtvoff=-1.8460889e-010    ptvoff=5.7333698e-016     kt1=-0.27594922
+ lkt1=-4.3655984e-008      wkt1=-1.143766e-008       pkt1=1.3285862e-014
+ kt1l=0                    kt2=-0.039351733          lkt2=-1.9960891e-009
+ wkt2=-6.2424987e-010      pkt2=9.3792265e-016       ute=-1.2723222
+ lute=-1.2256494e-007      wute=-4.3013646e-009      pute=2.4481439e-014
+ ua1=-4.4379697e-010       lua1=-9.1148102e-016      wua1=-1.8053936e-016
+ pua1=2.9534083e-022       ub1=-1.7669298e-018       lub1=-3.3653408e-025
+ wub1=1.010512e-024        pub1=-3.62415e-031        uc1=5.0818338e-011
+ luc1=-1.7695303e-017      wuc1=1.2496821e-018       puc1=-1.2269404e-023
+ prt=0                     at=159802.38              lat=-0.19817673
+ wat=-0.0043549264         pat=1.3207581e-008        fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=4.2e+40              noib=1.6e+24              noic=1.5e+9
+ lintnoi=-1.0e-7           jss=7.434e-7              jsd=7.434e-7
+ jsws=1.117e-11            jswd=1.117e-11            jswgs=1.8e-011
+ jswgd=1.8e-011            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.7                   bvd=9.7
+ xjbvs=1                   xjbvd=1                   jtsswgs=2.6e-010
+ jtsswgd=2.6e-010          njtsswg=25.9              xtsswgs=0.48
+ xtsswgd=0.48              tnjtsswg=1                vtsswgs=3
+ vtsswgd=3                 pbs=0.818                 pbd=0.818
+ cjs=cjp_5m                cjd=cjp_5m                mjs=0.359
+ mjd=0.359                 pbsws=0.721               pbswd=0.721
+ cjsws=cjswp_5m            cjswd=cjswp_5m            mjsws=0.366
+ mjswd=0.366               pbswgs=0.721              pbswgd=0.721
+ cjswgs=cjswgp_5m          cjswgd=cjswgp_5m          mjswgs=0.366
+ mjswgd=0.366              tpb=1.41e-03              tcj=7.56e-04
+ tpbsw=8.25e-04            tcjsw=6.43e-04            tpbswg=8.25e-4
+ tcjswg=6.43e-4            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lvsat=0+dlvsatp_5m
+ pvsat=0+dpvsatp_5m        rshg=8.41                 minr=1e-3
 
     9: type=p 
+ lmin=8e-07                lmax=1.2e-006-dxlp_5m     wmin=5e-007-dxwp_5m
+ wmax=1.2e-006-dxwp_5m     version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.41442122+dvthp_5m
+ lvth0=1.776737e-008+dlvthp_5m                       wvth0=1.8028975e-008+dwvthp_5m
+ pvth0=3.5679946e-015+dpvthp_5m                      k1=0.6596
+ k2=0.044778706+dk2p_5m    lk2=4.4487668e-010        wk2=-3.4063956e-009+dwk2p_5m
+ pk2=-1.1092327e-015       k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0003929457          lcit=7.9620262e-011
+ wcit=-1.4425554e-011      pcit=-3.1032249e-017      voff=-0.11208335
+ lvoff=-1.4067282e-009     wvoff=-1.3516603e-008     pvoff=7.3733795e-015
+ nfactor=0.5               eta0=0.008593067          weta0=2.4449317e-008
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.014066406+du0p_5m
+ lu0=-9.6803905e-010+dlu0p_5m                        wu0=-7.9886718e-010+dwu0p_5m
+ pu0=4.9369992e-016+dpu0p_5m                         ua=2.701159e-009
+ lua=-1.5123455e-016       wua=-7.4460198e-016       pua=3.5065693e-022
+ ub=-8.1991019e-020        lub=2.8963623e-025        wub=3.4875176e-025
+ pub=-4.7598263e-031       uc=-7.3262799e-011        luc=2.1554462e-017
+ wuc=-1.051803e-017        puc=-6.3781041e-024       vsat=79371.786
+ lvsat=0.0057295221+dlvsatp_5m                       wvsat=0.0068101393
+ pvsat=-6.9327218e-009+dpvsatp_5m                    a0=1.0540141
+ la0=-3.2560641e-007       wa0=1.7498241e-007        pa0=-5.3658047e-014
+ ags=0.25423392            lags=-5.1067773e-008      wags=-7.4569099e-008
+ pags=6.1338421e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.06470575
+ lketa=2.5291707e-008      wketa=3.6754827e-008      pketa=-2.4307511e-014
+ dwg=0                     dwb=0                     pclm=-0.56720805
+ lpclm=7.7033316e-007      wpclm=5.4241461e-007      ppclm=-4.169339e-013
+ pdiblc1=0                 pdiblc2=0.0020612061      lpdiblc2=-6.7877954e-010
+ wpdiblc2=-2.1858121e-009  ppdiblc2=1.6777185e-015   pdiblcb=-0.2
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=4.11e+008          pscbe2=1e-006             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.49                  rdsw=1000                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=6.7                beta0=37.6                agidl=3.6503933e-012
+ lagidl=-7.6519458e-019    wagidl=5.8643587e-018     pagidl=-2.5470821e-024
+ bgidl=1.0679e+009         cgidl=150                 egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_5m              cgdo=cgop_5m              cgbo=0
+ cgdl=cglp_5m              cgsl=cglp_5m              clc=1e-007
+ cle=0.6                   cf=cfp_5m                 ckappas=0.6
+ ckappad=0.6               acde=1                    moin=23.25
+ noff=2.4                  voffcv=-0.028             tvoff=0.0005988481
+ ltvoff=2.5593123e-009     wtvoff=2.9536492e-009     ptvoff=-2.6214098e-015
+ kt1=-0.28026472           lkt1=-3.9262806e-008      wkt1=1.1334786e-008
+ pkt1=-9.8964881e-015      kt1l=0                    kt2=-0.034688933
+ lkt2=-6.7428199e-009      wkt2=-3.0045799e-009      pkt2=3.3610986e-015
+ ute=-1.4029896            lute=1.0454421e-008       wute=1.1983505e-008
+ pute=7.9034415e-015       ua1=-4.9770894e-010       lua1=-8.5659863e-016
+ wua1=-4.3803762e-016      pua1=5.5747405e-022       ub1=-5.9428203e-018
+ lub1=3.9145225e-024       wub1=3.0428617e-024       pub1=-2.431347e-030
+ uc1=-8.3902783e-011       luc1=1.194508e-016        wuc1=8.2369456e-017
+ puc1=-9.4849334e-023      prt=0                     at=59865.75
+ lat=-0.096441239          wat=-0.047585506          pat=5.7216311e-008
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=4.2e+40              noib=1.6e+24
+ noic=1.5e+9               lintnoi=-1.0e-7           jss=7.434e-7
+ jsd=7.434e-7              jsws=1.117e-11            jswd=1.117e-11
+ jswgs=1.8e-011            jswgd=1.8e-011            njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.7
+ bvd=9.7                   xjbvs=1                   xjbvd=1
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=25.9
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1
+ vtsswgs=3                 vtsswgd=3                 pbs=0.818
+ pbd=0.818                 cjs=cjp_5m                cjd=cjp_5m
+ mjs=0.359                 mjd=0.359                 pbsws=0.721
+ pbswd=0.721               cjsws=cjswp_5m            cjswd=cjswp_5m
+ mjsws=0.366               mjswd=0.366               pbswgs=0.721
+ pbswgd=0.721              cjswgs=cjswgp_5m          cjswgd=cjswgp_5m
+ mjswgs=0.366              mjswgd=0.366              tpb=1.41e-03
+ tcj=7.56e-04              tpbsw=8.25e-04            tcjsw=6.43e-04
+ tpbswg=8.25e-4            tcjswg=6.43e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ rshg=8.41                 minr=1e-3
 
     10: type=p 
+ lmin=1e-005-dxlp_5m       lmax=900.01e-6            wmin=2.2e-07
+ wmax=5e-007-dxwp_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.38560714+dvthp_5m
+ wvth0=-3.7703571e-009+dwvthp_5m                     k1=0.6596
+ k2=0.049214286+dk2p_5m    wk2=-4.1892857e-009+dwk2p_5m
+ k3=0                      k3b=0.14                  w0=0
+ dvt0=1.3                  dvt1=0.26936              dvt2=0.03
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.195               voffl=0
+ dvtp0=4.5e-007            dvtp1=0.1                 lpe0=7e-008
+ lpeb=2.5e-008             xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0002                voff=-0.14124571          wvoff=6.4850143e-009
+ nfactor=0.5               eta0=0.056309571          weta0=1.1394857e-010
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.013612643+du0p_5m
+ wu0=-3.8792786e-010+dwu0p_5m                        ua=2.019e-009
+ wua=-2.6979e-016          ub=1.2643275e-019         wub=-1.3480703e-026
+ uc=-8.2985893e-011        wuc=-5.5738446e-018       vsat=89107.143
+ wvsat=-0.0020946429       a0=1.2840714              wa0=-3.2676429e-008
+ ags=0.13608214            wags=-1.0598893e-008      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.0014137321         wketa=1.3189966e-009      dwg=0
+ dwb=0                     pclm=0.31928571           wpclm=-2.5135714e-008
+ pdiblc1=0                 pdiblc2=-1.3928571e-005   wpdiblc2=3.7703571e-011
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=6.7                beta0=37.6
+ agidl=-3.75e-012          wagidl=1.46625e-017       bgidl=1.0774357e+009
+ wbgidl=22.370786          cgidl=150                 egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_5m              cgdo=cgop_5m              cgbo=0
+ cgdl=cglp_5m              cgsl=cglp_5m              clc=1e-007
+ cle=0.6                   cf=cfp_5m                 ckappas=0.6
+ ckappad=0.6               acde=1                    moin=23.25
+ noff=2.4                  voffcv=-0.028             tvoff=0.0026151041
+ ltvoff=0                  wtvoff=4.1360864e-010     ptvoff=0
+ kt1=-0.3102967            wkt1=5.1650416e-009       kt1l=0
+ kt2=-0.045769002          wkt2=2.6404004e-009       ute=-1.3251924
+ wute=1.878924e-008        ua1=-1.5202063e-009       wua1=3.5116369e-016
+ ub1=6.8139714e-019        wub1=-2.9252944e-025      uc1=4.9016e-011
+ prt=0                     at=142378.79              wat=-0.0044180207
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=4.2e+40              noib=1.6e+24
+ noic=1.5e+9               lintnoi=-1.0e-7           jss=7.434e-7
+ jsd=7.434e-7              jsws=1.117e-11            jswd=1.117e-11
+ jswgs=1.8e-011            jswgd=1.8e-011            njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.7
+ bvd=9.7                   xjbvs=1                   xjbvd=1
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=25.9
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1
+ vtsswgs=3                 vtsswgd=3                 pbs=0.818
+ pbd=0.818                 cjs=cjp_5m                cjd=cjp_5m
+ mjs=0.359                 mjd=0.359                 pbsws=0.721
+ pbswd=0.721               cjsws=cjswp_5m            cjswd=cjswp_5m
+ mjsws=0.366               mjswd=0.366               pbswgs=0.721
+ pbswgd=0.721              cjswgs=cjswgp_5m          cjswgd=cjswgp_5m
+ mjswgs=0.366              mjswgd=0.366              tpb=1.41e-03
+ tcj=7.56e-04              tpbsw=8.25e-04            tcjsw=6.43e-04
+ tpbswg=8.25e-4            tcjswg=6.43e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ pu0=0+dpu0p_5m            lu0=0+dlu0p_5m            lvth0=0+dlvthp_5m
+ pvth0=0+dpvthp_5m         lvsat=0+dlvsatp_5m        pvsat=0+dpvsatp_5m
+ rshg=8.41                 minr=1e-3
 
     11: type=p 
+ lmin=1.2e-006-dxlp_5m     lmax=1e-005-dxlp_5m       wmin=2.2e-07
+ wmax=5e-007-dxwp_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.38939167+dvthp_5m
+ lvth0=3.7156514e-008+dlvthp_5m                      wvth0=-4.0972221e-009+dwvthp_5m
+ pvth0=3.2091602e-015+dpvthp_5m                      k1=0.6596
+ k2=0.049461349+dk2p_5m    lk2=-2.4256667e-009       wk2=-4.0438984e-009+dwk2p_5m
+ pk2=-1.4274126e-015       k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00017092191         lcit=2.8548871e-010
+ wcit=4.0272793e-012       pcit=-3.9539829e-017      voff=-0.14300633
+ lvoff=1.7285706e-008      wvoff=7.21988e-009        pvoff=-7.2149115e-015
+ nfactor=0.5               eta0=0.056309592          leta0=-1.9859646e-013
+ weta0=1.1394392e-010      peta0=4.5677187e-020      etab=-0.061
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.013522799+du0p_5m    lu0=8.8208307e-010+dlu0p_5m
+ wu0=-3.2134049e-010+dwu0p_5m                        pu0=-6.5375474e-016+dpu0p_5m
+ ua=1.9688809e-009         lua=4.9206974e-016        wua=-2.6063061e-016
+ pua=-8.9926933e-023       ub=1.3371435e-019         lub=-7.1490792e-026
+ wub=-9.4983032e-027       pub=-3.9099196e-032       uc=-8.5414e-011
+ luc=2.3839159e-017        wuc=-4.8615925e-018       puc=-6.9928913e-024
+ vsat=89278.187            lvsat=-0.0016793083+dlvsatp_5m
+ wvsat=-0.0021818752       pvsat=8.5644725e-010+dpvsatp_5m
+ a0=1.3129269              la0=-2.8330303e-007       wa0=-3.2874337e-008
+ pa0=1.9430647e-015        ags=0.12424252            lags=1.162414e-007
+ wags=-8.1418482e-009      pags=-2.4123264e-014      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.0040194505         lketa=-2.5582942e-008     wketa=1.0881459e-009
+ pketa=2.2664922e-015      dwg=0                     dwb=0
+ pclm=0.29751274           lpclm=2.1376703e-007      wpclm=-2.465109e-008
+ ppclm=-4.7580403e-015     pdiblc1=0                 pdiblc2=-3.0165349e-005
+ lpdiblc2=1.5941269e-010   wpdiblc2=2.9464962e-011   ppdiblc2=8.0886666e-017
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=6.7                beta0=37.6
+ agidl=-1.9076286e-012     lagidl=-1.8088403e-017    wagidl=1.4637857e-017
+ pagidl=2.4194678e-025     bgidl=1.0785388e+009      lbgidl=-10.830322
+ wbgidl=24.958679          pbgidl=-2.5407935e-005    cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5m              cgdo=cgop_5m
+ cgbo=0                    cgdl=cglp_5m              cgsl=cglp_5m
+ clc=1e-007                cle=0.6                   cf=cfp_5m
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=23.25                noff=2.4                  voffcv=-0.028
+ tvoff=0.00239464          ltvoff=2.1645159e-009     wtvoff=5.00727e-010
+ ptvoff=-8.5532806e-016    kt1=-0.31013313           lkt1=-1.6059631e-009
+ wkt1=5.9961323e-009       pkt1=-8.1596489e-015      kt1l=0
+ kt2=-0.046081103          lkt2=3.0642102e-009       wkt2=2.8077288e-009
+ pkt2=-1.64283e-015        ute=-1.3169376            lute=-8.1045461e-008
+ wute=1.845246e-008        pute=3.3065049e-015       ua1=-1.5378773e-009
+ lua1=1.7349385e-016       wua1=3.7744158e-016       pua1=-2.5799636e-022
+ ub1=9.6978277e-019        lub1=-2.8313701e-024      wub1=-3.8521139e-025
+ pub1=9.0995137e-031       uc1=5.4954997e-011        luc1=-5.8309072e-017
+ wuc1=-8.6001404e-019      puc1=8.4436178e-024       prt=0
+ at=161096.8               lat=-0.18377345           wat=-0.005015078
+ pat=5.861909e-009         fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.13                   noia=4.2e+40
+ noib=1.6e+24              noic=1.5e+9               lintnoi=-1.0e-7
+ jss=7.434e-7              jsd=7.434e-7              jsws=1.117e-11
+ jswd=1.117e-11            jswgs=1.8e-011            jswgd=1.8e-011
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.7                   bvd=9.7                   xjbvs=1
+ xjbvd=1                   jtsswgs=2.6e-010          jtsswgd=2.6e-010
+ njtsswg=25.9              xtsswgs=0.48              xtsswgd=0.48
+ tnjtsswg=1                vtsswgs=3                 vtsswgd=3
+ pbs=0.818                 pbd=0.818                 cjs=cjp_5m
+ cjd=cjp_5m                mjs=0.359                 mjd=0.359
+ pbsws=0.721               pbswd=0.721               cjsws=cjswp_5m
+ cjswd=cjswp_5m            mjsws=0.366               mjswd=0.366
+ pbswgs=0.721              pbswgd=0.721              cjswgs=cjswgp_5m
+ cjswgd=cjswgp_5m          mjswgs=0.366              mjswgd=0.366
+ tpb=1.41e-03              tcj=7.56e-04              tpbsw=8.25e-04
+ tcjsw=6.43e-04            tpbswg=8.25e-4            tcjswg=6.43e-4
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   rshg=8.41                 minr=1e-3
 
     12: type=p 
+ lmin=8e-07                lmax=1.2e-006-dxlp_5m     wmin=2.2e-07
+ wmax=5e-007-dxwp_5m       version=4.5               binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_5m              toxm=toxp_5m              dtox=1.365e-010
+ epsrox=3.9                wint=0                    lint=7.6e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-3e-08+dxlp_5m         xw=1e-08+dxwp_5m
+ dlc=1.1e-008              dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=-0.38768115+dvthp_5m
+ lvth0=3.5415199e-008+dlvthp_5m                      wvth0=4.391539e-009+dwvthp_5m
+ pvth0=-5.4323986e-015+dpvthp_5m                     k1=0.6596
+ k2=0.054742874+dk2p_5m    lk2=-7.8022595e-009       wk2=-8.4881217e-009+dwk2p_5m
+ pk2=3.0968067e-015        k3=0                      k3b=0.14
+ w0=0                      dvt0=1.3                  dvt1=0.26936
+ dvt2=0.03                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.56029329           minv=-0.195
+ voffl=0                   dvtp0=4.5e-007            dvtp1=0.1
+ lpe0=7e-008               lpeb=2.5e-008             xj=1.5e-007
+ ngate=1.5e+021            ndep=1.424026e+017        nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00080020686         lcit=-3.5512338e-010
+ wcit=-2.2212875e-010      pcit=1.9068701e-016       voff=-0.13190159
+ lvoff=5.9810768e-009      wvoff=-3.409305e-009      pvoff=3.6055989e-015
+ nfactor=0.5               eta0=0.056309397          weta0=1.1398879e-010
+ etab=-0.061               ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.014028479+du0p_5m
+ lu0=3.6730169e-010+dlu0p_5m                         wu0=-7.7952406e-010+dwu0p_5m
+ pu0=-1.8732386e-016+dpu0p_5m                        ua=1.4710648e-009
+ lua=9.9884649e-016        wua=-1.1725392e-016       pua=-2.358844e-022
+ ub=1.4868333e-018         lub=-1.4489658e-024       wub=-4.5134862e-025
+ pub=4.1070443e-031        uc=-7.7906714e-011        luc=1.6196741e-017
+ wuc=-8.1496328e-018       puc=-3.6456663e-024       vsat=99287.804
+ lvsat=-0.011869098+dlvsatp_5m                       wvsat=-0.0033470298
+ pvsat=2.0425746e-009+dpvsatp_5m                     a0=1.6785522
+ la0=-6.555096e-007        wa0=-1.4353202e-007       pa0=1.1459258e-013
+ ags=0.11460786            lags=1.2604949e-007       wags=-3.3598071e-009
+ pags=-2.8991382e-014      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.0035721333
+ lketa=-1.785471e-008      wketa=5.5766821e-009      pketa=-2.3028377e-015
+ dwg=0                     dwb=0                     pclm=0.61730536
+ lpclm=-1.1178185e-007     wpclm=-6.1687232e-008     ppclm=3.2944752e-014
+ pdiblc1=0                 pdiblc2=-0.0027682391     lpdiblc2=2.9467718e-009
+ wpdiblc2=2.7720499e-010   ppdiblc2=-1.7131269e-016  pdiblcb=-0.2
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=4.11e+008          pscbe2=1e-006             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.49                  rdsw=1000                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=6.7                beta0=37.6                agidl=-4.9471197e-011
+ lagidl=3.033131e-017      wagidl=3.295637e-017      pagidl=-1.84063e-023
+ bgidl=1.0679e+009         cgidl=150                 egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop_5m              cgdo=cgop_5m              cgbo=0
+ cgdl=cglp_5m              cgsl=cglp_5m              clc=1e-007
+ cle=0.6                   cf=cfp_5m                 ckappas=0.6
+ ckappad=0.6               acde=1                    moin=23.25
+ noff=2.4                  voffcv=-0.028             tvoff=0.0085801321
+ ltvoff=-4.1323151e-009    wtvoff=-1.1168056e-009    ptvoff=7.9132017e-016
+ kt1=-0.22161763           lkt1=-9.1714747e-008      wkt1=-1.8575234e-008
+ pkt1=1.6854002e-014       kt1l=0                    kt2=-0.044062373
+ lkt2=1.0091434e-009       wkt2=1.7758748e-009       pkt2=-5.9240265e-016
+ ute=-1.1965222            lute=-2.0362834e-007      wute=-9.3314873e-008
+ pute=1.1708565e-013       ua1=8.626024e-010         lua1=-2.2701945e-015
+ wua1=-1.1317964e-015      pua1=1.2784079e-021       ub1=-5.4182809e-018
+ lub1=3.6716787e-024       wub1=2.7753466e-024       pub1=-2.3074967e-030
+ uc1=4.7534354e-011        luc1=-5.0754857e-017      wuc1=1.5336517e-017
+ puc1=-8.0444503e-024      prt=0                     at=-77227.446
+ lat=0.058840629           wat=0.022332024           pat=-2.1977441e-008
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=4.2e+40              noib=1.6e+24
+ noic=1.5e+9               lintnoi=-1.0e-7           jss=7.434e-7
+ jsd=7.434e-7              jsws=1.117e-11            jswd=1.117e-11
+ jswgs=1.8e-011            jswgd=1.8e-011            njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.7
+ bvd=9.7                   xjbvs=1                   xjbvd=1
+ jtsswgs=2.6e-010          jtsswgd=2.6e-010          njtsswg=25.9
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1
+ vtsswgs=3                 vtsswgd=3                 pbs=0.818
+ pbd=0.818                 cjs=cjp_5m                cjd=cjp_5m
+ mjs=0.359                 mjd=0.359                 pbsws=0.721
+ pbswd=0.721               cjsws=cjswp_5m            cjswd=cjswp_5m
+ mjsws=0.366               mjswd=0.366               pbswgs=0.721
+ pbswgd=0.721              cjswgs=cjswgp_5m          cjswgd=cjswgp_5m
+ mjswgs=0.366              mjswgd=0.366              tpb=1.41e-03
+ tcj=7.56e-04              tpbsw=8.25e-04            tcjsw=6.43e-04
+ tpbswg=8.25e-4            tcjswg=6.43e-4            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ rshg=8.41                 minr=1e-3
 
 
     } 
endsection mos_5m
 
// **************************************************************

section mos_na
// *********************************************************************************************
//                                                                            
//                   *
//                              1.8V CORE NATIVE NMOS DEVICE MODELS           
//                     *
//                                                                            
//                   *
// *********************************************************************************************
 
 
// *********************************
//        Mismatch   model         * 
// *********************************
 
inline subckt nanch_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2.05e-007 dmci=3.15e-007 
+ xw= + 0 + dxwn_na ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf 
+ * dmcg + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor 
+ + (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 
+ 1) * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.00e-05 / factor sb=1.00e-05 / factor 
+ sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_na 
+ temp1=par1n_na temp2=par2n_na fac1=0.089793 * temp1 * sigma + 0.995960 * temp2 
+ * sigma fac2=0.089793 * temp1 * sigma - 0.995960 * temp2 * sigma lef=l * factor 
+ - 1.5e-08 wef=w / nf * factor + 0 geo_fac=1 / sqrt(multi * nf * lef * wef * 1e12) 
+ vthmisn_na=0.00372278 * geo_fac * fac1 * mismatchflag dlmisn_na=0.00357013 * geo_fac 
+ * lef * fac2 * mismatchflag dwmisn_na= - 0.00357013 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisn_na=0.00357013 * geo_fac * toxn_na * fac2 * mismatchflag 
nanch_mac ( n1 n2 n3 n4 ) nanch w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model nanch bsim4  { 
     1: type=n 
+ lmin=1e-005-(dxln_na+dlmisn_na)                     lmax=900.01e-6
+ wmin=1.003e-005-(dxwn_na+dwmisn_na)                 wmax=900.01e-6
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.033+(dvth0n_na+vthmisn_na)                  k1=0.042
+ k2=0.0030793+dk2n_na      k3=-2.2                   k3b=0
+ w0=0                      dvt0=9.8                  dvt1=1.336
+ dvt2=0.09984              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.55                 minv=0
+ voffl=0                   dvtp0=1.532e-005          dvtp1=1
+ lpe0=1.759e-007           lpeb=3.058e-009           xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0                     voff=-0.075
+ nfactor=1.1               eta0=0.21                 etab=-0.0416
+ u0=0.056+du0n_na          ua=9.221e-010             ub=1.992e-018
+ uc=-2.5346e-011           vsat=234100               a0=4.116
+ ags=1.8                   a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.02348
+ dwg=0                     dwb=0                     pclm=0.7724
+ pdiblc1=0                 pdiblc2=0.03803           pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.37195              pkt1=0
+ wkt1=0                    lkt1=0                    kt1l=0
+ kt2=-0.015                pkt2=0                    wkt2=0
+ lkt2=0                    ute=-1.9                  pute=0
+ wute=0                    lute=0                    ua1=1.0103e-09
+ pua1=0                    wua1=0                    lua1=0
+ ub1=-2.2188e-18           pub1=0                    wub1=0
+ lub1=0                    uc1=-4e-011               prt=0
+ at=300000                 jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvth0n_na        wvth0=0+dwvth0n_na
+ lu0=0+dlu0n_na            pu0=0+dpu0n_na            wk2=0+dwk2n_na
+ lvoff=0+dlvoffn_na        saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 pvoff=0+dpvoffn_na        fnoimod=1
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=4.10e7                 ef=0.93                   minr=1e-3
 
 
 
     2: type=n 
+ lmin=3e-006-(dxln_na+dlmisn_na)                     lmax=1e-005-(dxln_na+dlmisn_na)
+ wmin=1.003e-005-(dxwn_na+dwmisn_na)                 wmax=900.01e-6
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.030245482+(dvth0n_na+vthmisn_na)            lvth0=-2.7452639e-008+dlvth0n_na
+ k1=0.042                  k2=0.0035260828+dk2n_na   lk2=-4.4528181e-009
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.083390686         lvoff=8.3624963e-008+dlvoffn_na
+ nfactor=1.1423772         lnfactor=-4.223483e-007   eta0=0.21
+ etab=-0.0416              u0=0.055576228+du0n_na    lu0=4.223483e-009+dlu0n_na
+ ua=1.0819044e-009         lua=-1.5926754e-015       ub=1.6580677e-018
+ lub=3.3281046e-024        uc=-2.0817996e-011        luc=-4.5127915e-017
+ vsat=234100               a0=4.116                  ags=1.8050853
+ lags=-5.0681796e-008      a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.020717007
+ lketa=-2.7537109e-008     dwg=0                     dwb=0
+ pclm=0.67594949           lpclm=9.6126472e-007      pdiblc1=0
+ pdiblc2=0.041432889       lpdiblc2=-3.3914568e-008  pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.36819962           pkt1=0
+ wkt1=0                    lkt1=-3.737782e-08        kt1l=0
+ kt2=-0.015                pkt2=0                    wkt2=0
+ lkt2=0                    ute=-1.9500051            pute=0
+ wute=0                    lute=4.98371e-07          ua1=9.277492e-10
+ pua1=0                    wua1=0                    lua1=8.227345e-16
+ ub1=-2.2466418e-18        pub1=0                    wub1=0
+ lub1=2.774828e-25         uc1=-4.3559685e-011       luc1=3.5477257e-017
+ prt=0                     at=300000                 jss=4.98e-07
+ jsd=4.98e-07              jsws=4.12e-13             jswd=4.12e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn_na
+ cjd=cjn_na                mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn_na
+ cjswd=cjswn_na            mjsws=0.202               mjswd=0.202
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgn_na
+ cjswgd=cjswgn_na          mjswgs=0.583              mjswgd=0.583
+ tpb=0.00149               tcj=9.05e-04              tpbsw=0.000894
+ tcjsw=0.000809            tpbswg=0.00115            tcjswg=0.000928
+ xtis=3                    xtid=3                    dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rshg=8.23                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wvth0=0+dwvth0n_na
+ pu0=0+dpu0n_na            wk2=0+dwk2n_na            saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.8                 wlod=5.00e-07
+ tku0=0.03                 ku0=-2.80e-08             llodku0=1
+ wlodku0=1                 lku0=2.00e-07             wku0=3.00e-06
+ pku0=-5.00e-14            kvth0=1.30e-08            stk2=2.50e-09
+ steta0=-1.10e-10          lkvth0=-1.00e-08          wkvth0=1.00e-06
+ pkvth0=-5.00e-14          llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 pvoff=0+dpvoffn_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     3: type=n 
+ lmin=1.2e-006-(dxln_na+dlmisn_na)                   lmax=3e-006-(dxln_na+dlmisn_na)
+ wmin=1.003e-005-(dxwn_na+dwmisn_na)                 wmax=900.01e-6
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.039824001+(dvth0n_na+vthmisn_na)            lvth0=9.6111819e-010+dlvth0n_na
+ k1=0.042                  k2=0.00070488987+dk2n_na  lk2=3.91598e-009
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.052089589         lvoff=-9.2267346e-009+dlvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056351998+du0n_na    lu0=1.9222364e-009+dlu0n_na
+ ua=3.1366321e-010         lua=6.8623839e-016        ub=3.1882414e-018
+ lub=-1.2110089e-024       uc=-3.9344883e-011        luc=9.8303169e-018
+ vsat=234100               a0=4.116                  ags=1.7672639
+ lags=6.1511564e-008       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.038119468
+ lketa=2.4085622e-008      dwg=0                     dwb=0
+ pclm=1.1474853            lpclm=-4.37501e-007       pdiblc1=0
+ pdiblc2=0.033240011       lpdiblc2=-9.6111819e-009  pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.39022843           pkt1=0
+ wkt1=0                    lkt1=2.7968539e-08        kt1l=0
+ kt2=-0.014351997          pkt2=0                    wkt2=0
+ lkt2=-1.9222364e-09       ute=-1.782                ua1=1.2842211e-09
+ pua1=0                    wua1=0                    lua1=-2.3470507e-16
+ ub1=-1.6035293e-18        pub1=0                    wub1=0
+ lub1=-1.6302487e-24       uc1=-3.9116826e-011       luc1=2.2297942e-017
+ prt=0                     at=364800.22              lat=-0.19222364
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvth0n_na        pu0=0+dpu0n_na            wk2=0+dwk2n_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ pvoff=0+dpvoffn_na        fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     4: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-(dxln_na+dlmisn_na)
+ wmin=1.003e-005-(dxwn_na+dwmisn_na)                 wmax=900.01e-6
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.049327517+(dvth0n_na+vthmisn_na)            lvth0=1.2046057e-008+dlvth0n_na
+ k1=0.042                  k2=0.0048179744+dk2n_na   lk2=-8.8153825e-010
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.037346091         lvoff=-2.642361e-008+dlvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056840653+du0n_na    lu0=1.3522671e-009+dlu0n_na
+ ua=9.2378773e-010         lua=-2.5413295e-017       ub=1.8634947e-018
+ lub=3.3418095e-025        uc=-1.6488459e-011        luc=-1.6829508e-017
+ vsat=234100               a0=4.116                  ags=1.7467079
+ lags=8.5488149e-008       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.023869196
+ lketa=7.464048e-009       dwg=0                     dwb=0
+ pclm=0.75401036           lpclm=2.1449754e-008      pdiblc1=0
+ pdiblc2=0.0016798         lpdiblc2=2.7200775e-008   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.38701022           pkt1=0
+ wkt1=0                    lkt1=2.4214805e-08        kt1l=0
+ kt2=-0.015368666          pkt2=0                    wkt2=0
+ lkt2=-7.3639077e-10       ute=-1.9818874            lute=2.331495e-007
+ ua1=-1.9397447e-11        pua1=0                    wua1=0
+ lua1=1.2858408e-15        ub1=-1.847338e-18         pub1=0
+ wub1=0                    lub1=-1.3458693e-24       uc1=-3.16601e-011
+ luc1=1.3600387e-017       prt=0                     at=256801.14
+ pat=0                     wat=0                     lat=-0.066253078
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvth0n_na        pu0=0+dpu0n_na            saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.8                 wlod=5.00e-07
+ tku0=0.03                 ku0=-2.80e-08             llodku0=1
+ wlodku0=1                 lku0=2.00e-07             wku0=3.00e-06
+ pku0=-5.00e-14            kvth0=1.30e-08            stk2=2.50e-09
+ steta0=-1.10e-10          lkvth0=-1.00e-08          wkvth0=1.00e-06
+ pkvth0=-5.00e-14          llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wk2=0+dwk2n_na
+ pvoff=0+dpvoffn_na        fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     5: type=n 
+ lmin=1e-005-(dxln_na+dlmisn_na)                     lmax=900.01e-6
+ wmin=1.23e-006-(dxwn_na+dwmisn_na)                  wmax=1.003e-005-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.035258546+(dvth0n_na+vthmisn_na)            wvth0=2.2680765e-008+dwvth0n_na
+ k1=0.042                  k2=0.003231653+dk2n_na    wk2=-1.5299594e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.075705796         wvoff=7.0877391e-009
+ nfactor=1.1141159         wnfactor=-1.4175478e-007  eta0=0.21
+ etab=-0.0416              u0=0.056282318+du0n_na    wu0=-2.8350957e-009
+ ua=8.8033103e-010         wua=4.194524e-016         ub=2.1204548e-018
+ wub=-1.2899685e-024       uc=-1.7209025e-011        wuc=-8.1713127e-017
+ vsat=234100               a0=4.116                  ags=1.8230089
+ wags=-2.310603e-007       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.019582598
+ wketa=-3.9138495e-008     dwg=0                     dwb=0
+ pclm=0.7724               pdiblc1=0                 pdiblc2=0.037751917
+ wpdiblc2=2.7925692e-009   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.37123008           pkt1=0                    wkt1=-7.229494e-09
+ lkt1=0                    kt1l=0                    kt2=-0.015
+ pkt2=0                    wkt2=0                    lkt2=0
+ ute=-1.9166567            pute=0                    lute=0
+ wute=1.6727065e-07        ua1=9.6730293e-10         pua1=0
+ lua1=0                    wua1=4.3178514e-16        ub1=-2.1440139e-18
+ pub1=0                    lub1=0                    wub1=-7.5101684e-25
+ uc1=-4.3077268e-011       wuc1=3.0902543e-017       prt=0
+ at=300000                 jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvth0n_na        lu0=0+dlu0n_na
+ pu0=0+dpu0n_na            lvoff=0+dlvoffn_na        saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.8                 wlod=5.00e-07
+ tku0=0.03                 ku0=-2.80e-08             llodku0=1
+ wlodku0=1                 lku0=2.00e-07             wku0=3.00e-06
+ pku0=-5.00e-14            kvth0=1.30e-08            stk2=2.50e-09
+ steta0=-1.10e-10          lkvth0=-1.00e-08          wkvth0=1.00e-06
+ pkvth0=-5.00e-14          llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 pvoff=0+dpvoffn_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     6: type=n 
+ lmin=3e-006-(dxln_na+dlmisn_na)                     lmax=1e-005-(dxln_na+dlmisn_na)
+ wmin=1.23e-006-(dxwn_na+dwmisn_na)                  wmax=1.003e-005-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.031756287+(dvth0n_na+vthmisn_na)            lvth0=-3.4904927e-008+dlvth0n_na
+ wvth0=1.5171802e-008+dwvth0n_na                     pvth0=7.4837363e-014
+ k1=0.042                  k2=0.0037415033+dk2n_na   lk2=-5.0813738e-009
+ wk2=-2.1632954e-009+dwk2n_na                        pk2=6.3120826e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.084981806         lvoff=9.2448471e-008+dlvoffn_na
+ wvoff=1.5978352e-008      pvoff=-8.8607438e-014+dpvoffn_na
+ nfactor=1.162475          lnfactor=-4.819666e-007   wnfactor=-2.0182649e-007
+ pnfactor=5.9869891e-013   eta0=0.21                 etab=-0.0416
+ u0=0.055978185+du0n_na    lu0=3.0311169e-009+dlu0n_na
+ wu0=-4.0365298e-009       pu0=1.1973978e-014+dpu0n_na
+ ua=1.0449928e-009         lua=-1.6410855e-015       wua=3.7067417e-016
+ pua=4.8614351e-022        ub=1.7962132e-018         lub=3.2315229e-024
+ wub=-1.3872847e-024       pub=9.6989223e-031        uc=-1.0698671e-011
+ luc=-6.4884824e-017       wuc=-1.0162029e-016       puc=1.9840283e-022
+ vsat=234100               a0=4.116                  ags=1.8331788
+ lags=-1.0135735e-007      wags=-2.8212125e-007      pags=5.0889407e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.014766607         lketa=-4.799811e-008
+ wketa=-5.9755105e-008     pketa=2.0547347e-013      dwg=0
+ dwb=0                     pclm=0.66233463           lpclm=1.096956e-006
+ wpclm=1.3672321e-007      ppclm=-1.3626387e-012     pdiblc1=0
+ pdiblc2=0.041699759       lpdiblc2=-3.9345795e-008  wpdiblc2=-2.6799634e-009
+ ppdiblc2=5.454147e-014    pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.36719019           lkt1=-4.0263347e-08       wkt1=-1.0136964e-08
+ pkt1=2.897702e-14         kt1l=0                    kt2=-0.015
+ pkt2=0                    wkt2=9.9999996e-19        lkt2=0
+ ute=-1.9737205            lute=5.6872068e-07        wute=2.381553e-07
+ pute=-7.0646463e-13       ua1=8.6187728e-10         lua1=1.0507148e-15
+ wua1=6.6149924e-16        pua1=-2.2894245e-21       ub1=-2.1596765e-18
+ lub1=1.560999e-25         wub1=-8.7332285e-25       pub1=1.218951e-30
+ uc1=-4.8443495e-011       luc1=5.3481984e-017       wuc1=4.9044198e-017
+ puc1=-1.8080707e-022      prt=0                     at=300000
+ lat=0                     wat=0                     pat=0
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     7: type=n 
+ lmin=1.2e-006-(dxln_na+dlmisn_na)                   lmax=3e-006-(dxln_na+dlmisn_na)
+ wmin=1.23e-006-(dxwn_na+dwmisn_na)                  wmax=1.003e-005-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.042703643+(dvth0n_na+vthmisn_na)            lvth0=-2.4306461e-009+dlvth0n_na
+ wvth0=2.8917936e-008+dwvth0n_na                     pvth0=3.4060775e-014
+ k1=0.042                  k2=0.0005284763+dk2n_na   lk2=4.4497623e-009
+ wk2=1.7715804e-009+dwk2n_na                         pk2=-5.3603485e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.051599906         lvoff=-6.5757317e-009+dlvoffn_na
+ wvoff=-4.9174993e-009     pvoff=-2.6621902e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056260526+du0n_na    lu0=2.1935775e-009+dlu0n_na
+ wu0=9.1857414e-010        pu0=-2.724862e-015+dpu0n_na
+ ua=2.2557236e-010         lua=7.896465e-016         wua=8.8462589e-016
+ pua=-1.0384449e-021       ub=3.3417594e-018         lub=-1.3531917e-024
+ wub=-1.5416586e-024       pub=1.4278277e-030        uc=-3.6841016e-011
+ luc=1.2663932e-017        wuc=-2.514434e-017        puc=-2.8455734e-023
+ vsat=234100               a0=4.116                  ags=1.8073622
+ lags=-2.4774918e-008      wags=-4.0267531e-007      pags=8.6650612e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.039853025         lketa=2.6418342e-008
+ wketa=1.7408728e-008      pketa=-2.3425639e-014     dwg=0
+ dwb=0                     pclm=1.200432             lpclm=-4.9925825e-007
+ wpclm=-5.3170136e-007     ppclm=6.2017859e-013      pdiblc1=0
+ pdiblc2=0.031074087       lpdiblc2=-7.8257572e-009  wpdiblc2=2.1750648e-008
+ ppdiblc2=-1.7929592e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.39159857           lkt1=3.2141767e-08        wkt1=1.3759108e-08
+ pkt1=-4.1908378e-14       kt1l=0                    kt2=-0.014260527
+ pkt2=2.724862e-15         wkt2=-9.1857412e-10       lkt2=-2.1935776e-09
+ ute=-1.782                lute=0                    wute=-1e-14
+ pute=0                    ua1=1.2562768e-09         lua1=-1.1923313e-16
+ wua1=2.8062324e-16        pua1=-1.1595923e-21       ub1=-1.4496658e-18
+ lub1=-1.9500785e-24       wub1=-1.5451275e-24       pub1=3.2117949e-30
+ uc1=-3.8992158e-011       luc1=2.5445499e-017       wuc1=-1.2519417e-018
+ puc1=-3.1608399e-023      prt=0                     at=366172.29
+ lat=-0.19629376           wat=-0.013778612          pat=4.087293e-08
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     8: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-(dxln_na+dlmisn_na)
+ wmin=1.23e-006-(dxwn_na+dwmisn_na)                  wmax=1.003e-005-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.057372314+(dvth0n_na+vthmisn_na)            lvth0=1.4678951e-008+dlvth0n_na
+ wvth0=8.078746e-008+dwvth0n_na                      pvth0=-2.6440045e-014
+ k1=0.042                  k2=0.0054445827+dk2n_na   lk2=-1.2844039e-009
+ wk2=-6.292526e-009+dwk2n_na                         pk2=4.0456574e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.03095598          lvoff=-3.0654889e-008+dlvoffn_na
+ wvoff=-6.4170775e-008     pvoff=4.2491355e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.05681816+du0n_na     lu0=1.5431519e-009+dlu0n_na
+ wu0=2.2588211e-010        pu0=-1.9169033e-015+dpu0n_na
+ ua=9.5752489e-010         lua=-6.4105862e-017       wua=-3.3879533e-016
+ pua=3.8855849e-022        ub=1.8146049e-018         lub=4.2808749e-025
+ wub=4.9096126e-025        pub=-9.4302827e-031       uc=-6.0916871e-012
+ luc=-2.3202208e-017       wuc=-1.0440646e-016       puc=6.3995925e-023
+ vsat=234833.61            lvsat=-0.00085569044      wvsat=-0.0073670997
+ pvsat=8.5930146e-009      a0=3.8229306              la0=3.4183736e-007
+ wa0=2.9430619e-006        pa0=-3.4327992e-012       ags=2.1200797
+ lags=-3.8952975e-007      wags=-3.7494734e-006      pags=4.7702248e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.024893915         lketa=8.9699754e-009
+ wketa=1.0290427e-008      pketa=-1.5122824e-014     dwg=0
+ dwb=0                     pclm=0.75141449           lpclm=2.4477581e-008
+ wpclm=2.6068199e-008      ppclm=-3.0406052e-014     pdiblc1=0
+ pdiblc2=-0.0012597167     lpdiblc2=2.988852e-008    wpdiblc2=2.9519214e-008
+ ppdiblc2=-2.6990879e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.38648104           lkt1=2.6172664e-08        wkt1=-5.314191e-09
+ pkt1=-1.9661206e-14       kt1l=0                    kt2=-0.015509825
+ pkt2=0                    wkt2=1.4175478e-09        lkt2=-7.3639081e-10
+ ute=-2.0101034            lute=2.6606067e-007       wute=2.8334999e-007
+ pute=-3.3050056e-013      ua1=-4.5357002e-11        lua1=1.3989976e-15
+ wua1=2.6069111e-16        pua1=-1.1363434e-21       ub1=-1.9617078e-18
+ lub1=-1.3528308e-24       wub1=1.148524e-24         pub1=6.990904e-32
+ uc1=-2.8677028e-011       luc1=1.3413891e-017       wuc1=-2.9956606e-017
+ puc1=1.8728365e-024       prt=0                     at=254781.26
+ lat=-0.066366805          wat=0.020284079           pat=1.142071e-09
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     9: type=n 
+ lmin=1e-005-(dxln_na+dlmisn_na)                     lmax=900.01e-6
+ wmin=5.3e-007-(dxwn_na+dwmisn_na)                   wmax=1.23e-006-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.020563029+(dvth0n_na+vthmisn_na)            wvth0=4.4259941e-009+dwvth0n_na
+ k1=0.042                  k2=-0.0045025271+dk2n_na  wk2=8.0774392e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.065817314         wvoff=-5.1957322e-009
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.052450857+du0n_na    wu0=1.9243453e-009        ua=1.2567286e-009
+ wua=-4.8108631e-017       ub=8.5892343e-019         wub=2.7710572e-025
+ uc=-7.3290042e-011        wuc=-1.2049288e-017       vsat=234100
+ a0=4.116                  ags=1.9584471             wags=-3.9930164e-007
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.062003711         wketa=1.3557012e-008
+ dwg=0                     dwb=0                     pclm=0.7724
+ pdiblc1=0                 pdiblc2=0.068282934       wpdiblc2=-3.513306e-008
+ pdiblcb=0                 drout=0.5                 pvag=0.309
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=65.92                 rdw=65.92                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=0
+ bgidl=0                   cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=1.257                moin=24.64
+ noff=3.328                voffcv=-0.0428            kt1=-0.3787773
+ pkt1=0                    lkt1=0                    wkt1=2.145645e-09
+ kt1l=0                    kt2=-0.015                pkt2=0
+ lkt2=0                    wkt2=0                    ute=-1.782
+ ua1=1.7135332e-09         pua1=0                    lua1=0
+ wua1=-4.9518214e-16       ub1=-3.4752255e-018       wub1=9.0261414e-025
+ uc1=-1.3143429e-012       wuc1=-2.0975363e-017      prt=0
+ at=300000                 jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvth0n_na        lu0=0+dlu0n_na
+ pu0=0+dpu0n_na            saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 lvoff=0+dlvoffn_na        pvoff=0+dpvoffn_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     10: type=n 
+ lmin=3e-006-(dxln_na+dlmisn_na)                     lmax=1e-005-(dxln_na+dlmisn_na)
+ wmin=5.3e-007-(dxwn_na+dwmisn_na)                   wmax=1.23e-006-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.015851519+(dvth0n_na+vthmisn_na)            lvth0=-4.6956804e-008+dlvth0n_na
+ wvth0=-4.5851001e-009+dwvth0n_na                    pvth0=8.9808205e-014
+ k1=0.042                  k2=-0.0036802817+dk2n_na  lk2=-8.19483e-009
+ wk2=7.056046e-009+dwk2n_na                          pk2=1.0179618e-014
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.071619046         lvoff=5.7822402e-008+dlvoffn_na
+ wvoff=-6.2086898e-010     pvoff=-4.5594935e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.0508513+du0n_na      lu0=1.5941838e-008+dlu0n_na
+ wu0=2.3320871e-009        pu0=-4.0637197e-015+dpu0n_na
+ ua=1.2914952e-009         lua=-3.4649804e-016       wua=6.4468885e-017
+ pua=-1.121993e-021        ub=5.4923243e-019         lub=3.0865057e-024
+ wub=1.6171478e-025        pub=1.1500327e-030        uc=-8.3609611e-011
+ luc=1.0284899e-016        wuc=-1.105032e-017        puc=-9.9561133e-024
+ vsat=234100               a0=4.116                  ags=1.9340766
+ lags=2.4288647e-007       wags=-4.0745648e-007      pags=8.1274394e-014
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.086054247         lketa=2.3969736e-007
+ wketa=2.8798402e-008      pketa=-1.5190184e-013     dwg=0
+ dwb=0                     pclm=0.7724               pdiblc1=0
+ pdiblc2=0.071595214       lpdiblc2=-3.3011525e-008  wpdiblc2=-3.9816097e-008
+ ppdiblc2=4.667304e-014    pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.38022581           lkt1=1.4436452e-08        wkt1=6.0558897e-09
+ pkt1=-3.8971077e-14       kt1l=0                    kt2=-0.015
+ lkt2=-5.1e-16             wkt2=-1.45e-16            pkt2=2.4e-22
+ ute=-1.782                lute=0                    wute=0
+ pute=0                    ua1=1.9808364e-09         lua1=-2.6640508e-15
+ wua1=-7.2847167e-16       pua1=2.3250572e-21        ub1=-4.1325216e-018
+ lub1=6.5508789e-024       wub1=1.5773453e-024       pub1=-6.7246434e-030
+ uc1=1.5079555e-011        luc1=-1.6338821e-016      wuc1=-2.9864135e-017
+ puc1=8.8589089e-023       prt=0                     at=300000.01
+ lat=0                     wat=0                     pat=0
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     11: type=n 
+ lmin=1.2e-006-(dxln_na+dlmisn_na)                   lmax=3e-006-(dxln_na+dlmisn_na)
+ wmin=5.3e-007-(dxwn_na+dwmisn_na)                   wmax=1.23e-006-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.045224711+(dvth0n_na+vthmisn_na)            lvth0=4.0175949e-008+dlvth0n_na
+ wvth0=3.2049607e-008+dwvth0n_na                     pvth0=-1.8865137e-014
+ k1=0.042                  k2=-0.00885727+dk2n_na    lk2=7.1622088e-009
+ wk2=1.3430555e-008+dwk2n_na                         pk2=-8.7297497e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.037570625         lvoff=-4.3178971e-008+dlvoffn_na
+ wvoff=-2.2344672e-008     pvoff=1.8846642e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.057731201+du0n_na    lu0=-4.4667282e-009+dlu0n_na
+ wu0=-9.0829738e-010       pu0=5.5485697e-015+dpu0n_na
+ ua=1.3986533e-009         lua=-6.6437218e-016       wua=-5.7257519e-016
+ pua=7.677371e-022         ub=1.5171163e-018         lub=2.1537093e-025
+ wub=7.2491301e-025        pub=-5.2064079e-031       uc=-4.8176957e-011
+ luc=-2.2585767e-018       wuc=-1.1062834e-017       puc=-9.9189931e-024
+ vsat=234100               a0=2.8029668              la0=3.8949869e-006
+ wa0=1.6310498e-006        pa0=-4.8383528e-012       ags=2.8507242
+ lags=-2.4762606e-006      wags=-1.6987395e-006      pags=3.9117416e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.000442124         lketa=-1.4262789e-008
+ wketa=-3.1547494e-008     pketa=2.7108462e-014      dwg=0
+ dwb=0                     pclm=0.7724               pdiblc1=0
+ pdiblc2=0.071168372       lpdiblc2=-3.1745339e-008  wpdiblc2=-2.8054474e-008
+ ppdiblc2=1.1783313e-014   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.36887351           lkt1=-1.9239026e-08       wkt1=-1.4469947e-08
+ pkt1=2.191685e-14         kt1l=0                    kt2=-0.015501924
+ pkt2=-1.8495233e-15       wkt2=6.2349e-10           lkt2=1.4889094e-09
+ ute=-1.782                lute=0                    wute=0
+ pute=0                    ua1=1.6174262e-09         lua1=-1.5860295e-15
+ wua1=-1.6799675e-16       pua1=6.624622e-22         ub1=-2.4260468e-18
+ lub1=1.4887853e-24        wub1=-3.32267e-25         pub1=-1.0599618e-30
+ uc1=-3.5382299e-011       luc1=-1.3697966e-017      wuc1=-5.736108e-018
