+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.49241047+(dvthp+vthmisp)
+ lvth0=1.0705825e-009+dlvthp                         wvth0=-1.7142946e-009+dwvthp
+ pvth0=7.1678087e-016      k1=0.493                  k2=0.056440429+dk2p
+ lk2=8.314315e-010+dlk2p   wk2=-3.6385299e-009+dwk2p pk2=-3.2882721e-016
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0055000001     lkvth0we=5.8000025e-011
+ wkvth0we=-9.8999965e-011  pkvth0we=4.7999992e-017   k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00081359137
+ lcit=-2.2318605e-011+dlcitp                         wcit=-1.5229316e-010+dwcitp
+ pcit=1.0066789e-017+dpcitp                          voff=-0.15167884+dvoffp+0.0085607722
+ tvoff=0.0033512133        ptvoff=6.371386e-18       wtvoff=-6.4934632e-11
+ ltvoff=1.4598951e-11      lvoff=4.6961502e-009+dlvoffp-3.5794301e-09
+ wvoff=1.3314046e-009+dwvoffp-2.2857262e-09          pvoff=-1.9305298e-016+dpvoffp+9.5570783e-16
+ nfactor=1                 eta0=0.19443335           leta0=-2.2717904e-009+dleta0p
+ weta0=1.3181021e-009+dweta0p                        peta0=-5.5112485e-016+dpeta0p
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.016704734+du0p
+ lu0=5.1091887e-010+dlu0p  wu0=-8.2495321e-010+dwu0p pu0=-1.1844406e-016
+ ua=1.8777014e-009         lua=1.8183616e-016        wua=4.6955918e-016
+ pua=-3.485785e-023        ub=3.5667728e-018         lub=1.4382307e-025
+ wub=-1.4979463e-024       pub=-5.4609145e-032       uc=6.1745049e-011
+ luc=-1.5524884e-017       wuc=-1.1950388e-016       puc=5.5431054e-025
+ vsat=84312.007            lvsat=0.0028372891+dlvsatp
+ wvsat=-0.0014239441+dwvsatp                         pvsat=-8.2050703e-010+dpvsatp
+ a0=1.2131375              la0=9.8415509e-009        wa0=7.6902339e-009
+ pa0=1.5922092e-014        ags=1.320679+dagsp        lags=-1.2055482e-007
+ wags=-2.6968456e-007      pags=3.280053e-014        a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.14103023          lketa=8.9042862e-009      wketa=2.9435177e-008
+ pketa=-1.9324412e-015     dwg=0                     dwb=0
+ pclm=0.43394723           lpclm=2.4673915e-009+dlpclmp
+ wpclm=1.5028595e-007+dwpclmp                        ppclm=-1.8453444e-014+dppclmp
+ pdiblc1=0                 pdiblc2=0.0028285795      lpdiblc2=-4.7449802e-011+dlpdiblc2p
+ wpdiblc2=2.2608022e-011+dwpdiblc2p                  ppdiblc2=-7.8113186e-018+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.17209166
+ lkt1=2.2606857e-09        wkt1=6.7089159e-09        pkt1=-1.3443624e-15
+ kt1l=0                    kt2=-0.045                lkt2=8e-17
+ wkt2=5e-16                pkt2=9.9999998e-24        ute=0.43954123
+ lute=-1.6048817e-07       wute=-4.2228673e-07       pute=5.0894633e-14
+ ua1=1.7026317e-08         lua1=-1.6652429e-15       wua1=-4.0628112e-15
+ pua1=4.578159e-22         ub1=-1.9106345e-17        lub1=1.5742541e-24
+ wub1=3.7620911e-24        pub1=-3.9296157e-31       uc1=-5.2872513e-10
+ luc1=1.0918861e-16        wuc1=1.5694624e-16        puc1=-2.0222142e-23
+ prt=0                     at=97517.211              lat=-0.017786729
+ wat=-0.025688225          pat=4.714825e-09          jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
     } 
ends pch_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                               1.8 V STD-SVT  NMOS DEVICE MODELS            
//                   *
//                                                                            
//                   *
// *********************************************************************************************
model nch bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln          lmax=2e-05                wmin=1.003e-005-dxwn
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.43953+dvthn        k1=0.448                  k2=0.044342+dk2
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.0034927135      lkvth0we=0
+ wkvth0we=0                pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00082854+dcitn
+ voff=-0.13055+dvoffn      tvoff=1.500000e-03        nfactor=0.94972
+ eta0=0.22771+deta0n       etab=-0.308               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.030526+du0n          ua=-1.1118e-009
+ ub=2.3263e-018            uc=1.9167e-010            vsat=73329+dvsatn
+ a0=1.0724+da0n            ags=0.50072               a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.051375            dwg=0                     dwb=0
+ pclm=0.71887+dpclmn       pdiblc1=0                 pdiblc2=0.000975+dpdiblc2n
+ pdiblcb=0                 drout=0.5                 pvag=0.6279
+ delta=0.005               pscbe1=4.5e+008           pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=90.88                 rdw=90.88                 prwg=0
+ prwb=0                    wr=1                      alpha0=1.454e-007
+ alpha1=2.295              beta0=17.8                agidl=2.593e-009
+ bgidl=1.8508e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.346
+ noff=1.973                voffcv=-0.0904            kt1=-0.24611586
+ kt1l=0                    kt2=-0.055191541          pkt2=0
+ wkt2=0                    lkt2=0                    ute=-1.8116912
+ ua1=2.3415359e-009        ub1=-4.4298745e-018       uc1=-8.0699954e-011
+ prt=0                     at=117848.51              pat=0
+ wat=0                     lat=0                     jss=2.85e-07
+ jsd=2.85e-07              jsws=6.9e-13              jswd=6.9e-13
+ jswgs=6.9e-13             jswgd=6.9e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn
+ cjd=cjn                   mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.202               mjswd=0.202
+ pbswgs=0.952              pbswgd=0.952              cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.541              mjswgd=0.541
+ tpb=1.49e-3               tcj=9.05e-4               tpbsw=8.94e-04
+ tcjsw=8.09e-04            tpbswg=0.00133            tcjswg=0.00088
+ xtis=3                    xtid=3                    jtsswgs=1.09e-009
+ jtsswgd=1.09e-009         njtsswg=11.6              xtsswgs=0.2886
+ xtsswgd=0.2886            tnjtsswg=1.08             vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-3.2e-008             lku0=2e-007
+ wku0=7e-007               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 lvth0=0+dlvthn            wvth0=0+dwvthn
+ pvth0=0+dpvthn            lk2=0+dlk2                lcit=0+dlcitn
+ pcit=0+dpcitn             lvoff=0+dlvoffn           pvoff=0+dpvoffn
+ leta0=0+dleta0n           peta0=0+dpeta0n           lu0=0+dlu0n
+ pu0=0+dpu0n               lvsat=0+dlvsatn           pvsat=0+dpvsatn
+ la0=0+dla0n               pa0=0+dpa0n               lpclm=0+dlpclmn
+ ppclm=0+dppclmn           lpdiblc2=0+dlpdiblc2n     ppdiblc2=0+dppdiblc2n
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     2: type=n 
+ lmin=1.2e-006-dxln        lmax=1e-005-dxln          wmin=1.003e-005-dxwn
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.44000255+dvthn     lvth0=-4.6939282e-009+dlvthn
+ k1=0.448                  k2=0.044420158+dk2        lk2=-7.763527e-010+dlk2
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.0035080237      lkvth0we=-1.5207765e-010
+ wkvth0we=0                pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00094159467+dcitn
+ lcit=-1.1229833e-009+dlcitn                         voff=-0.13088478+dvoffn
+ tvoff=1.500000e-03        lvoff=3.3253987e-009+dlvoffn
+ nfactor=0.94802421        lnfactor=1.6844423e-008   eta0=0.2200075+deta0n
+ leta0=7.650975e-008+dleta0n                         etab=-0.308
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.031147016+du0n
+ lu0=-6.1686146e-009+dlu0n ua=-1.0351999e-009        lua=-7.608768e-016
+ ub=2.2622927e-018         lub=6.3579065e-025        uc=1.9814412e-010
+ luc=-6.4308095e-017       vsat=73219.038+dvsatn     lvsat=0.0010922656+dlvsatn
+ a0=1.0632966+da0n         la0=9.0425265e-008+dla0n  ags=0.47288051
+ lags=2.7653248e-007       a1=0                      a2=0.995
+ b0=0                      b1=0                      keta=-0.044517814
+ lketa=-6.8113118e-008     dwg=0                     dwb=0
+ pclm=0.73030143+dpclmn    lpclm=-1.1354958e-007+dlpclmn
+ pdiblc1=0                 pdiblc2=0.00083459861+dpdiblc2n
+ lpdiblc2=1.3946211e-009+dlpdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.24355302           pkt1=0
+ wkt1=0                    lkt1=-2.5456989e-08       kt1l=0
+ kt2=-0.055236684          pkt2=0                    wkt2=0
+ lkt2=4.48417e-10          ute=-1.8758               lute=6.3679863e-007
+ ua1=2.2474837e-09         pua1=0                    wua1=0
+ lua1=9.3422973e-16        ub1=-4.4202733e-018       lub1=-9.5370005e-026
+ uc1=-7.421409e-11         puc1=0                    wuc1=0
+ luc1=-6.442474e-17        prt=0                     at=122782.95
+ pat=0                     wat=0                     lat=-0.049014274
+ jss=2.85e-07              jsd=2.85e-07              jsws=6.9e-13
+ jswd=6.9e-13              jswgs=6.9e-13             jswgd=6.9e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn                   cjd=cjn                   mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.202
+ mjswd=0.202               pbswgs=0.952              pbswgd=0.952
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.541
+ mjswgd=0.541              tpb=1.49e-3               tcj=9.05e-4
+ tpbsw=8.94e-04            tcjsw=8.09e-04            tpbswg=0.00133
+ tcjswg=0.00088            xtis=3                    xtid=3
+ jtsswgs=1.09e-009         jtsswgd=1.09e-009         njtsswg=11.6
+ xtsswgs=0.2886            xtsswgd=0.2886            tnjtsswg=1.08
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rshg=8.23                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ saref=1.00e-05            sbref=1.00e-05            rbsb=50
+ ngcon=1                   wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-3.2e-008
+ lku0=2e-007               wku0=7e-007               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 wvth0=0+dwvthn
+ pvth0=0+dpvthn            pcit=0+dpcitn             pvoff=0+dpvoffn
+ peta0=0+dpeta0n           pu0=0+dpu0n               pvsat=0+dpvsatn
+ pa0=0+dpa0n               ppclm=0+dppclmn           ppdiblc2=0+dppdiblc2n
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     3: type=n 
+ lmin=5e-007-dxln          lmax=1.2e-006-dxln        wmin=1.003e-005-dxwn
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.42487782+dvthn     lvth0=1.2443907e-008+dlvthn
+ k1=0.448                  k2=0.045638784+dk2        lk2=-2.1571775e-009+dlk2
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.0034998799      lkvth0we=-1.4284995e-010
+ wkvth0we=0                pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00046662469+dcitn
+ lcit=4.7267005e-010+dlcitn                          voff=-0.12040787+dvoffn
+ tvoff=1.500000e-03        lvoff=-8.5459843e-009+dlvoffn
+ nfactor=1.0247614         lnfactor=-7.0106516e-008  eta0=0.28753+deta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.021368288+du0n       lu0=4.9116625e-009+dlu0n  ua=-2.2464725e-009
+ lua=6.1161625e-016        ub=3.3377372e-018         lub=-5.8279547e-025
+ uc=1.5619583e-010         luc=-1.6776489e-017       vsat=81168.284+dvsatn
+ lvsat=-0.0079150256+dlvsatn                         a0=1.6098828+da0n
+ la0=-5.289116e-007+dla0n  ags=0.84742922            lags=-1.4786866e-007
+ a1=0                      a2=0.995                  b0=0
+ b1=0                      keta=-0.11739531          lketa=1.4464376e-008
+ dwg=0                     dwb=0                     pclm=0.61209779+dpclmn
+ lpclm=2.0386975e-008+dlpclmn                        pdiblc1=0
+ pdiblc2=0.0024032799+dpdiblc2n                      lpdiblc2=-3.8285168e-010+dlpdiblc2n
+ pdiblcb=0                 drout=0.5                 pvag=0.6279
+ delta=0.005               pscbe1=4.5e+008           pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=90.88                 rdw=90.88                 prwg=0
+ prwb=0                    wr=1                      alpha0=1.454e-007
+ alpha1=2.295              beta0=17.8                agidl=2.593e-009
+ bgidl=1.8508e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.346
+ noff=1.973                voffcv=-0.0904            kt1=-0.26648965
+ pkt1=0                    wkt1=0                    lkt1=5.32515e-10
+ kt1l=0                    kt2=-0.054653483          pkt2=0
+ wkt2=0                    lkt2=-2.124094e-10        ute=-1.3497898
+ lute=4.0776543e-008       ua1=3.2127884e-09         pua1=0
+ wua1=0                    lua1=-1.5955703e-16       ub1=-5.1065691e-018
+ lub1=6.8227184e-025       uc1=-2.2149083e-10        puc1=0
+ wuc1=0                    luc1=1.0245454e-16        prt=0
+ at=118385.18              pat=0                     wat=0
+ lat=-0.044031168          jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   saref=1.00e-05            sbref=1.00e-05
+ rbsb=50                   ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ wvth0=0+dwvthn            pvth0=0+dpvthn            pcit=0+dpcitn
+ pvoff=0+dpvoffn           leta0=0+dleta0n           peta0=0+dpeta0n
+ pu0=0+dpu0n               pvsat=0+dpvsatn           pa0=0+dpa0n
+ ppclm=0+dppclmn           ppdiblc2=0+dppdiblc2n     fnoimod=1
+ noia=noian                noib=noibn                noic=noicn
+ em=3.00e7                 ef=0.904                  minr=1e-3
 
 
     4: type=n 
+ lmin=1.8e-07              lmax=5e-007-dxln          wmin=1.003e-005-dxwn
+ wmax=90.003e-05           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.46146692+dvthn     lvth0=-3.4028302e-009+dlvthn
+ k1=0.448                  k2=0.039663073+dk2        lk2=4.3090269e-010+dlk2
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.00349988        lkvth0we=-1.4284997e-010
+ wkvth0we=0                pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00061599596+dcitn
+ lcit=3.7870453e-012+dlcitn                          voff=-0.14584802+dvoffn
+ tvoff=0.0013232813        ptvoff=0                  wtvoff=0
+ ltvoff=7.6536891e-11      lvoff=2.4721416e-009+dlvoffn
+ nfactor=0.78346906        lnfactor=3.4397209e-008   eta0=0.28753+deta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.030914951+du0n       lu0=7.7700251e-010+dlu0n  ua=-7.1464787e-010
+ lua=-5.1817006e-017       ub=1.5421034e-018         lub=1.9489354e-025
+ uc=7.8458172e-011         luc=1.6891692e-017        vsat=61073.15+dvsatn
+ lvsat=0.0007881769+dlvsatn                          a0=0.20832912+da0n
+ la0=7.8101305e-008+dla0n  ags=0.31869166            lags=8.1127573e-008
+ a1=0                      a2=0.995                  b0=0
+ b1=0                      keta=-0.09467464          lketa=4.6240528e-009
+ dwg=0                     dwb=0                     pclm=0.64898747+dpclmn
+ lpclm=4.4100556e-009+dlpclmn                        pdiblc1=0
+ pdiblc2=0.001415142+dpdiblc2n                       lpdiblc2=4.5110843e-011+dlpdiblc2n
+ pdiblcb=0                 drout=0.5                 pvag=0.6279
+ delta=0.005               pscbe1=4.5e+008           pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=90.88                 rdw=90.88                 prwg=0
+ prwb=0                    wr=1                      alpha0=1.454e-007
+ alpha1=2.295              beta0=17.8                agidl=2.593e-009
+ bgidl=1.8508e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.346
+ noff=1.973                voffcv=-0.0904            kt1=-0.25288273
+ pkt1=0                    wkt1=0                    lkt1=-5.3606467e-09
+ kt1l=0                    kt2=-0.05510829           pkt2=0
+ wkt2=0                    lkt2=-1.543206e-11        ute=-1.2573881
+ lute=7.5736315e-010       ua1=2.6668279e-09         pua1=0
+ wua1=0                    lua1=7.6898481e-17        ub1=-3.2787121e-018
+ lub1=-1.0937304e-025      uc1=-2.214721e-12         puc1=0
+ wuc1=0                    luc1=7.4860548e-18        prt=0
+ at=15560.798              pat=0                     wat=0
+ lat=0.00050207373         jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   saref=1.00e-05            sbref=1.00e-05
+ rbsb=50                   ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ wvth0=0+dwvthn            pvth0=0+dpvthn            pcit=0+dpcitn
+ pvoff=0+dpvoffn           leta0=0+dleta0n           peta0=0+dpeta0n
+ pu0=0+dpu0n               pvsat=0+dpvsatn           pa0=0+dpa0n
+ ppclm=0+dppclmn           ppdiblc2=0+dppdiblc2n     fnoimod=1
+ noia=noian                noib=noibn                noic=noicn
+ em=3.00e7                 ef=0.904                  minr=1e-3
 
 
     5: type=n 
+ lmin=1e-005-dxln          lmax=2e-05                wmin=1.23e-006-dxwn
+ wmax=1.003e-005-dxwn      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.43767024+dvthn     wvth0=1.8615454e-008+dwvthn
+ k1=0.448                  k2=0.044105166+dk2        wk2=2.3706154e-009
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.0034939762      lkvth0we=0
+ wkvth0we=-1.2638696e-011  pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00079963881+dcitn
+ wcit=2.8928938e-010       voff=-0.12992046+dvoffn   tvoff=1.500000e-03
+ wvoff=-6.3014618e-009     nfactor=0.88693351        wnfactor=6.2846762e-007
+ eta0=0.21639887+deta0n    weta0=1.1321993e-007      etab=-0.308
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.02998869+du0n
+ wu0=5.3782564e-009        ua=-1.203133e-009         wua=9.1420727e-016
+ ub=2.4226144e-018         wub=-9.6406862e-025       uc=2.0880233e-010
+ wuc=-1.7148782e-016       vsat=73808.304+dvsatn     wvsat=-0.0047976413
+ a0=1.0648537+da0n         wa0=7.5534989e-008        ags=0.50587729
+ wags=-5.1622455e-008      a1=0                      a2=0.995
+ b0=0                      b1=0                      keta=-0.053402592
+ wketa=2.0295385e-008      dwg=0                     dwb=0
+ pclm=0.72643962+dpclmn    wpclm=-7.5768887e-008     pdiblc1=0
+ pdiblc2=0.00097154989+dpdiblc2n                     wpdiblc2=3.4534212e-011
+ pdiblcb=0                 drout=0.5                 pvag=0.6279
+ delta=0.005               pscbe1=4.5e+008           pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=90.88                 rdw=90.88                 prwg=0
+ prwb=0                    wr=1                      alpha0=1.454e-007
+ alpha1=2.295              beta0=17.8                agidl=2.593e-009
+ bgidl=1.8508e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.346
+ noff=1.973                voffcv=-0.0904            kt1=-0.24969309
+ pkt1=0                    lkt1=0                    wkt1=3.580664e-08
+ kt1l=0                    kt2=-0.055217703          pkt2=0
+ lkt2=0                    wkt2=2.618748e-10         ute=-1.8450159
+ wute=3.3356664e-007       ua1=2.3109709e-09         pua1=0
+ lua1=0                    wua1=3.0594354e-16        ub1=-4.4511878e-018
+ wub1=2.1333736e-025       uc1=-8.7610598e-011       wuc1=6.9172781e-017
+ prt=0                     at=117036.91              pat=0
+ lat=0                     wat=0.008123733           jss=2.85e-07
+ jsd=2.85e-07              jsws=6.9e-13              jswd=6.9e-13
+ jswgs=6.9e-13             jswgd=6.9e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn
+ cjd=cjn                   mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.202               mjswd=0.202
+ pbswgs=0.952              pbswgd=0.952              cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.541              mjswgd=0.541
+ tpb=1.49e-3               tcj=9.05e-4               tpbsw=8.94e-04
+ tcjsw=8.09e-04            tpbswg=0.00133            tcjswg=0.00088
+ xtis=3                    xtid=3                    jtsswgs=1.09e-009
+ jtsswgd=1.09e-009         njtsswg=11.6              xtsswgs=0.2886
+ xtsswgd=0.2886            tnjtsswg=1.08             vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=1.00e-05            sbref=1.00e-05
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-3.2e-008             lku0=2e-007
+ wku0=7e-007               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 lvth0=0+dlvthn            pvth0=0+dpvthn
+ lk2=0+dlk2                lcit=0+dlcitn             pcit=0+dpcitn
+ lvoff=0+dlvoffn           pvoff=0+dpvoffn           leta0=0+dleta0n
+ peta0=0+dpeta0n           lu0=0+dlu0n               pu0=0+dpu0n
+ lvsat=0+dlvsatn           pvsat=0+dpvsatn           la0=0+dla0n
+ pa0=0+dpa0n               lpclm=0+dlpclmn           ppclm=0+dppclmn
+ lpdiblc2=0+dlpdiblc2n     ppdiblc2=0+dppdiblc2n     fnoimod=1
+ noia=noian                noib=noibn                noic=noicn
+ em=3.00e7                 ef=0.904                  minr=1e-3
 
 
     6: type=n 
+ lmin=1.2e-006-dxln        lmax=1e-005-dxln          wmin=1.23e-006-dxwn
+ wmax=1.003e-005-dxwn      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.43826899+dvthn     lvth0=-5.9474128e-009+dlvthn
+ wvth0=1.7352315e-008+dwvthn                         pvth0=1.254688e-014+dpvthn
+ k1=0.448                  k2=0.044096635+dk2        lk2=8.473674e-011+dlk2
+ wk2=3.2383366e-009        pk2=-8.6191608e-015       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035094668      lkvth0we=-1.5387034e-010  wkvth0we=-1.4445197e-011
+ pkvth0we=1.794415e-017    k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00091692734+dcitn   lcit=-1.1650387e-009+dlcitn
+ wcit=2.4691011e-010       pcit=4.2095749e-016+dpcitn
+ voff=-0.13043683+dvoffn   tvoff=1.500000e-03        lvoff=5.1291508e-009+dlvoffn
+ wvoff=-4.4838181e-009     pvoff=-1.8054837e-014+dpvoffn
+ nfactor=0.88311971        lnfactor=3.7882923e-008   wnfactor=6.4966815e-007
+ pnfactor=-2.1058697e-013  eta0=0.20763762+deta0n    leta0=8.7026363e-008+dleta0n
+ weta0=1.2381754e-007      peta0=-1.0526709e-013+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.030734961+du0n       lu0=-7.4127816e-009+dlu0n wu0=4.1245074e-009
+ pu0=1.2453614e-014+dpu0n  ua=-1.1100275e-009        lua=-9.2482661e-016
+ wua=7.489948e-016         pua=1.641072e-021         ub=2.3448197e-018
+ lub=7.727422e-025         wub=-8.2606234e-025       pub=-1.3708302e-030
+ uc=2.1675785e-010         luc=-7.9022914e-017       wuc=-1.8631596e-016
+ puc=1.4728946e-022        vsat=73706.519+dvsatn     lvsat=0.001011044+dlvsatn
+ wvsat=-0.0048794884       pvsat=8.1299557e-010+dpvsatn
+ a0=1.0494623+da0n         la0=1.5288501e-007+dla0n  wa0=1.3847577e-007
+ pa0=-6.2519711e-013+dpa0n ags=0.48226057            lags=2.3458734e-007
+ wags=-9.3890644e-008      pags=4.1985414e-013       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.046062599         lketa=-7.2908884e-008     wketa=1.5462685e-008
+ pketa=4.8003693e-014      dwg=0                     dwb=0
+ pclm=0.73944236+dpclmn    lpclm=-1.2915748e-007+dlpclmn
+ wpclm=-9.1496997e-008     ppclm=1.5622889e-013+dppclmn
+ pdiblc1=0                 pdiblc2=0.00082255572+dpdiblc2n
+ lpdiblc2=1.479974e-009+dlpdiblc2n                   wpdiblc2=1.2054455e-010
+ ppdiblc2=-8.5434924e-016+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.24727546           lkt1=-2.4014492e-08
+ wkt1=3.7260246e-08        pkt1=-1.4438818e-14       kt1l=0
+ kt2=-0.055269916          lkt2=5.1863176e-10        wkt2=3.326311e-10
+ pkt2=-7.02825e-16         ute=-1.9123217            lute=6.6855562e-007
+ wute=3.6556821e-007       pute=-3.1787476e-013      ua1=2.2105942e-09
+ lua1=9.9705133e-16        wua1=3.6924896e-16        pua1=-6.2881915e-22
+ ub1=-4.4301109e-018       lub1=-2.0935864e-025      wub1=9.8470839e-026
+ pub1=1.1409807e-030       uc1=-7.8971928e-11        luc1=-8.580875e-17
+ wuc1=4.7624082e-17        puc1=2.1404538e-22        prt=0
+ at=121701.61              lat=-0.04633491           wat=0.010823733
+ pat=-2.6819365e-08        jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     7: type=n 
+ lmin=5e-007-dxln          lmax=1.2e-006-dxln        wmin=1.23e-006-dxwn
+ wmax=1.003e-005-dxwn      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.42037368+dvthn     lvth0=1.4329762e-008+dlvthn
+ wvth0=4.5084673e-008+dwvthn                         pvth0=-1.8876655e-014+dpvthn
+ k1=0.448                  k2=0.046221224+dk2        lk2=-2.3226355e-009+dlk2
+ wk2=-5.8299975e-009       pk2=1.6561685e-015        k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035012271      lkvth0we=-1.4453387e-010  wkvth0we=-1.3484334e-011
+ pkvth0we=1.6855396e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00058574619+dcitn  lcit=5.3764069e-010+dlcitn
+ wcit=1.1923586e-009       pcit=-6.5033018e-016+dpcitn
+ voff=-0.11697501+dvoffn   tvoff=0.0015255135        ptvoff=2.8937131e-16
+ wtvoff=-2.553802e-10      ltvoff=-2.8909378e-11     lvoff=-1.0124436e-008+dlvoffn
+ wvoff=-3.4361596e-008     pvoff=1.5799673e-014+dpvoffn
+ nfactor=0.97842413        lnfactor=-7.0106516e-008  wnfactor=4.6381786e-007
+ pnfactor=-3.6153196e-028  eta0=0.2857596+deta0n     leta0=-1.4936512e-009+dleta0n
+ weta0=1.7721043e-008      peta0=1.4950851e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.018994069+du0n       lu0=5.8908231e-009+dlu0n  wu0=2.3764981e-008
+ pu0=-9.8010062e-015+dpu0n ua=-2.5857121e-009        lua=7.4727158e-016
+ wua=3.3956523e-015        pua=-1.3578556e-021       ub=3.6579891e-018
+ lub=-7.1521005e-025       wub=-3.2055939e-024       pub=1.325417e-030
+ uc=1.6778828e-010         luc=-2.3535502e-017       wuc=-1.1603581e-016
+ puc=6.7655012e-023        vsat=82472.125+dvsatn     lvsat=-0.0089212647+dlvsatn
+ wvsat=-0.013050925        pvsat=1.0072051e-008+dpvsatn
+ a0=1.7153328+da0n         la0=-6.016129e-007+dla0n  wa0=-1.0555125e-006
+ pa0=7.2771096e-013+dpa0n  ags=0.8525523             lags=-1.8499023e-007
+ wags=-5.1280026e-008      pags=3.7157205e-013       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.12659406          lketa=1.8341317e-008      wketa=9.2075794e-008
+ pketa=-3.8806621e-014     dwg=0                     dwb=0
+ pclm=0.60499108+dpclmn    lpclm=2.3189257e-008+dlpclmn
+ wpclm=7.1135264e-008      ppclm=-2.8049725e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0025232125+dpdiblc2n
+ lpdiblc2=-4.4704014e-010+dlpdiblc2n                 wpdiblc2=-1.2004774e-009
+ ppdiblc2=6.4250076e-016+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.27040689           lkt1=2.1957265e-09
+ wkt1=3.9210005e-08        pkt1=-1.6648091e-14       kt1l=0
+ kt2=-0.054513083          lkt2=-3.3893434e-10       wkt2=-1.4053344e-09
+ pkt2=1.2664632e-15        ute=-1.3645922            lute=4.7923298e-008
+ wute=1.4816586e-007       pute=-7.1536156e-014      ua1=3.2347934e-09
+ lua1=-1.634687e-16        wua1=-2.2026062e-16       pua1=3.915416e-23
+ ub1=-5.2851432e-018       lub1=7.594785e-025        wub1=1.7874554e-024
+ pub1=-7.7280775e-031      uc1=-2.5954626e-10        luc1=1.1880003e-16
+ wuc1=3.8091958e-16        puc1=-1.6361174e-22       prt=0
+ at=120571.33              lat=-0.045054185          wat=-0.021882427
+ pat=1.0239983e-08         jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     8: type=n 
+ lmin=1.8e-07              lmax=5e-007-dxln          wmin=1.23e-006-dxwn
+ wmax=1.003e-005-dxwn      version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.46153716+dvthn     lvth0=-3.4981445e-009+dlvthn
+ wvth0=-7.0316591e-010+dwvthn                        pvth0=9.5405814e-016+dpvthn
+ k1=0.448                  k2=0.04005708+dk2         lk2=3.4705556e-010+dlk2
+ wk2=-3.9438461e-009       pk2=8.3927631e-016        k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035012271      lkvth0we=-1.4453389e-010  wkvth0we=-1.3484357e-011
+ pkvth0we=1.6855406e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00063596926+dcitn   lcit=8.5157293e-012+dlcitn
+ wcit=-1.9992482e-010      pcit=-4.7332235e-017+dpcitn
+ voff=-0.14662081+dvoffn   tvoff=0.0012674705        ptvoff=-6.318266e-17
+ wtvoff=5.5864419e-10      ltvoff=8.2849096e-11      lvoff=2.7151615e-009+dlvoffn
+ wvoff=7.7353926e-009      pvoff=-2.4325323e-015+dpvoffn
+ nfactor=0.72621499        lnfactor=3.9125262e-008   wnfactor=5.7309035e-007
+ pnfactor=-4.7325917e-014  eta0=0.28035301+deta0n    leta0=8.4793969e-010+dleta0n
+ weta0=7.1838771e-008      peta0=-8.4875371e-015+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.030600569+du0n       lu0=8.6404784e-010+dlu0n  wu0=3.1468385e-009
+ pu0=-8.7128886e-016+dpu0n ua=-7.360552e-010         lua=-5.3814819e-017
+ wua=2.1427874e-016        pua=1.9997311e-023        ub=1.5214649e-018
+ lub=2.1011858e-025        wub=2.0658252e-025        pub=-1.5239657e-031
+ uc=7.1563125e-011         luc=1.8139615e-017        wuc=6.9016661e-017
+ puc=-1.2491212e-023       vsat=59837.656+dvsatn     lvsat=0.00088172379+dlvsatn
+ wvsat=0.012366802         pvsat=-9.36367e-010+dpvsatn
+ a0=0.12876526+da0n        la0=8.5529509e-008+dla0n  wa0=7.9640237e-007
+ pa0=-7.4353352e-014+dpa0n ags=0.19374941            lags=1.003373e-007
+ wags=1.2506219e-006       pags=-1.9228168e-013      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.094572384         lketa=4.4727282e-009      wketa=-1.0235369e-009
+ pketa=1.5146989e-015      dwg=0                     dwb=0
+ pclm=0.64375475+dpclmn    lpclm=6.400715e-009+dlpclmn
+ wpclm=5.2377423e-008      ppclm=-1.9925704e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0013400495+dpdiblc2n
+ lpdiblc2=6.5387753e-011+dlpdiblc2n                  wpdiblc2=7.5164568e-010
+ ppdiblc2=-2.0296376e-016+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.25205998           lkt1=-5.7503208e-09
+ wkt1=-8.235319e-09        pkt1=3.900481e-15         kt1l=0
+ kt2=-0.055305172          lkt2=4.11855e-12          wkt2=1.9706945e-09
+ pkt2=-1.956946e-16        ute=-1.2578727            lute=1.7030936e-009
+ wute=4.8507534e-009       pute=-9.4663839e-015      ua1=2.64976e-09
+ lua1=8.9909248e-17        wua1=1.7084239e-16        pua1=-1.3023256e-22
+ ub1=-3.2377504e-018       lub1=-1.2724735e-025      wub1=-4.1001048e-025
+ pub1=1.7891473e-031       uc1=-5.2478553e-12        luc1=8.6633837e-18
+ wuc1=3.0360468e-17        puc1=-1.1784594e-23       prt=0
+ at=15225.518              lat=0.00057108617         wat=0.0033560168
+ pat=-6.907862e-10         jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     9: type=n 
+ lmin=1e-005-dxln          lmax=2e-05                wmin=5.3e-007-dxwn
+ wmax=1.23e-006-dxwn       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.45091968+dvthn     wvth0=2.5889311e-009+dwvthn
+ k1=0.448                  k2=0.049658408+dk2        wk2=-4.3465863e-009
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.003492826       lkvth0we=0
+ wkvth0we=-1.1247497e-011  pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0011644892+dcitn
+ wcit=-1.5203366e-010      voff=-0.12502536+dvoffn   tvoff=1.500000e-03
+ wvoff=-1.2222573e-008     nfactor=1.3196496         wnfactor=1.0505424e-007
+ eta0=0.38866768+deta0n    weta0=-9.5156426e-008     etab=-0.308
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.037683336+du0n
+ wu0=-3.9291872e-009       ua=-2.803732e-010         wua=-2.0196304e-016
+ ub=1.6975264e-018         wub=-8.7002173e-026       uc=5.6835816e-011
+ wuc=1.2330885e-017        vsat=56060.96+dvsatn      wvsat=0.016669546
+ a0=1.2341704+da0n         wa0=-1.2927044e-007       ags=0.49009232
+ wags=-3.252895e-008       a1=0                      a2=0.995
+ b0=0                      b1=0                      keta=-0.02910376
+ wketa=-9.0964823e-009     dwg=0                     dwb=0
+ pclm=0.6638+dpclmn        pdiblc1=0                 pdiblc2=0.001072536+dpdiblc2n
+ wpdiblc2=-8.7618586e-011  pdiblcb=0                 drout=0.5
+ pvag=0.6279               delta=0.005               pscbe1=4.5e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=90.88                 rdw=90.88
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.454e-007         alpha1=2.295              beta0=17.8
+ agidl=2.593e-009          bgidl=1.8508e+009         cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5.346                noff=1.973                voffcv=-0.0904
+ kt1=-0.21715589           pkt1=0                    lkt1=0
+ wkt1=-3.550358e-09        kt1l=0                    kt2=-0.054972169
+ pkt2=0                    lkt2=0                    wkt2=-3.51231e-11
+ ute=-1.6297245            wute=7.3150159e-008       ua1=2.7228749e-09
+ pua1=0                    lua1=0                    wua1=-1.9229558e-16
+ ub1=-4.6663733e-018       wub1=4.7362574e-025       uc1=-1.5828853e-011
+ wuc1=-1.7654419e-017      prt=0                     at=105690.22
+ pat=0                     lat=0                     wat=0.021848693
+ jss=2.85e-07              jsd=2.85e-07              jsws=6.9e-13
+ jswd=6.9e-13              jswgs=6.9e-13             jswgd=6.9e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn                   cjd=cjn                   mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.202
+ mjswd=0.202               pbswgs=0.952              pbswgd=0.952
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.541
+ mjswgd=0.541              tpb=1.49e-3               tcj=9.05e-4
+ tpbsw=8.94e-04            tcjsw=8.09e-04            tpbswg=0.00133
+ tcjswg=0.00088            xtis=3                    xtid=3
+ jtsswgs=1.09e-009         jtsswgd=1.09e-009         njtsswg=11.6
+ xtsswgs=0.2886            xtsswgd=0.2886            tnjtsswg=1.08
+ vtsswgs=10                vtsswgd=10                dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rshg=8.23                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.00e-05
+ sbref=1.00e-05            wlod=5e-007               kvth0=2.2e-009
+ lkvth0=-1e-008            wkvth0=2.2e-006           pkvth0=-5e-014
+ llodvth=1                 wlodvth=1                 stk2=2.5e-009
+ lodk2=1                   lodeta0=2                 ku0=-3.2e-008
+ lku0=2e-007               wku0=7e-007               pku0=-5e-014
+ llodku0=1                 wlodku0=1                 kvsat=0.4
+ steta0=-1.1e-010          tku0=0.03                 lvth0=0+dlvthn
+ pvth0=0+dpvthn            lk2=0+dlk2                lcit=0+dlcitn
+ pcit=0+dpcitn             lvoff=0+dlvoffn           pvoff=0+dpvoffn
+ leta0=0+dleta0n           peta0=0+dpeta0n           lu0=0+dlu0n
+ pu0=0+dpu0n               lvsat=0+dlvsatn           pvsat=0+dpvsatn
+ la0=0+dla0n               pa0=0+dpa0n               lpclm=0+dlpclmn
+ ppclm=0+dppclmn           lpdiblc2=0+dlpdiblc2n     ppdiblc2=0+dppdiblc2n
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     10: type=n 
+ lmin=1.2e-006-dxln        lmax=1e-005-dxln          wmin=5.3e-007-dxwn
+ wmax=1.23e-006-dxwn       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.45009359+dvthn     lvth0=8.2056515e-009+dlvthn
+ wvth0=3.0492775e-009+dwvthn                         pvth0=-4.5726669e-015+dpvthn
+ k1=0.448                  k2=0.0506837+dk2          lk2=-1.0184325e-008+dlk2
+ wk2=-4.7293768e-009       pk2=3.8022964e-015        k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035081523      lkvth0we=-1.5223742e-010  wkvth0we=-1.2855149e-011
+ pkvth0we=1.5968969e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0012816735+dcitn    lcit=-1.1640036e-009+dlcitn
+ wcit=-1.9428688e-010      pcit=4.197055e-016+dpcitn voff=-0.12390125+dvoffn
+ tvoff=0.0014765654        ptvoff=-2.8156816e-16     wtvoff=2.8346454e-11
+ ltvoff=2.3277791e-10      lvoff=-1.116587e-008+dlvoffn
+ wvoff=-1.238925e-008      pvoff=1.6556208e-015+dpvoffn
+ nfactor=1.3034321         lnfactor=1.610905e-007    wnfactor=1.4125833e-007
+ pnfactor=-3.5961885e-013  eta0=0.38567368+deta0n    leta0=2.9739706e-008+dleta0n
+ weta0=-9.1534883e-008     peta0=-3.5973148e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.037135421+du0n       lu0=5.4424908e-009+dlu0n  wu0=-3.6174896e-009
+ pu0=-3.0961235e-015+dpu0n ua=-3.4387548e-010        lua=6.3077452e-016
+ wua=-1.777427e-016        pua=-2.405831e-022        ub=1.7416045e-018
+ lub=-4.3783223e-025       wub=-9.6413196e-026       pub=9.3480629e-032
+ uc=5.2319544e-011         luc=4.486058e-017         wuc=1.2588611e-017
+ puc=-2.5600177e-024       vsat=54415.882+dvsatn     lvsat=0.016340723+dlvsatn
+ wvsat=0.018454465         pvsat=-1.7729784e-008+dpvsatn
+ a0=1.2658264+da0n         la0=-3.1444254e-007+dla0n wa0=-1.2323831e-007
+ pa0=-5.9917704e-014+dpa0n ags=0.42466814            lags=6.4986497e-007
+ wags=-2.4226841e-008      pags=-8.2465682e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.02494072          lketa=-4.1351896e-008     wketa=-1.008634e-008
+ pketa=9.8323601e-015      dwg=0                     dwb=0
+ pclm=0.6638+dpclmn        pdiblc1=0                 pdiblc2=0.0010118305+dpdiblc2n
+ lpdiblc2=6.0299404e-010+dlpdiblc2n                  wpdiblc2=-1.0840221e-010
+ ppdiblc2=2.0644577e-016+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.21363667           lkt1=-3.4956736e-08
+ wkt1=-3.4292396e-09       pkt1=-1.203085e-15        kt1l=0
+ kt2=-0.054925589          lkt2=-4.626789e-10        wkt2=-8.386603e-11
+ pkt2=4.841688e-16         ute=-1.676861             lute=4.6821162e-007
+ wute=8.0754901e-008       pute=-7.5538655e-014      ua1=2.6804932e-09
+ lua1=4.2098151e-16        wua1=-1.9914087e-16       pua1=6.799488e-23
+ ub1=-4.7956442e-018       lub1=1.2840609e-024       wub1=5.4061989e-025
+ pub1=-6.6545954e-031      uc1=-2.6953883e-011       luc1=1.1050604e-016
+ wuc1=-1.5296949e-017      puc1=-2.3416982e-023      prt=0
+ at=110244.4               lat=-0.045237162          wat=0.02468237
+ pat=-2.8147196e-08        jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ lpclm=0+dlpclmn           ppclm=0+dppclmn           fnoimod=1
+ noia=noian                noib=noibn                noic=noicn
+ em=3.00e7                 ef=0.904                  minr=1e-3
 
 
     11: type=n 
+ lmin=5e-007-dxln          lmax=1.2e-006-dxln        wmin=5.3e-007-dxwn
+ wmax=1.23e-006-dxwn       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.46386651+dvthn     lvth0=-7.4004438e-009+dlvthn
+ wvth0=-7.5242539e-009+dwvthn                        pvth0=7.4082015e-015+dpvthn
+ k1=0.448                  k2=0.041798436+dk2        lk2=-1.164329e-010+dlk2
+ wk2=-4.8019262e-010       pk2=-1.0124542e-015       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0034999999      lkvth0we=-1.4299998e-010  wkvth0we=-1.2000002e-011
+ pkvth0we=1.5000003e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0002093576+dcitn    lcit=5.1037543e-011+dlcitn
+ wcit=2.3060105e-010       pcit=-6.1735013e-017+dpcitn
+ voff=-0.14158636+dvoffn   tvoff=0.0015639493        ptvoff=9.260252e-17
+ wtvoff=-3.0187213e-10     ltvoff=1.3376323e-10      lvoff=8.8731293e-009+dlvoffn
+ wvoff=-4.5917007e-009     pvoff=-7.179782e-015+dpvoffn
+ nfactor=1.5074714         lnfactor=-7.0106516e-008  wnfactor=-1.7611776e-007
+ pnfactor=-8.4625901e-029  eta0=0.444895+deta0n      leta0=-3.7363969e-008+dleta0n
+ weta0=-1.7476914e-007     peta0=5.8339587e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.047238653+du0n       lu0=-6.0054812e-009+dlu0n wu0=-1.0399669e-008
+ pu0=4.5887635e-015+dpu0n  ua=7.1915788e-010         lua=-5.7374858e-016
+ wua=-6.0191843e-016       pua=2.4005042e-022        ub=1.1708869e-018
+ lub=2.0884787e-025        wub=-1.9719508e-025       pub=2.0767658e-031
+ uc=6.3459404e-011         luc=3.2238005e-017        wuc=1.0160408e-017
+ puc=1.9137854e-025        vsat=72259.383+dvsatn     lvsat=-0.0038777484+dlvsatn
+ wvsat=-0.00069759276      pvsat=3.9714134e-009+dpvsatn
+ a0=1.1074481+da0n         la0=-1.3498409e-007+dla0n wa0=-3.2021516e-007
+ pa0=1.6327676e-013+dpa0n  ags=1.0257791             lags=-3.1253821e-008
+ wags=-2.6081511e-007      pags=1.8561249e-013       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.044894245         lketa=-1.8742556e-008     wketa=-6.7483042e-009
+ pketa=6.0500312e-015      dwg=0                     dwb=0
+ pclm=0.74766895+dpclmn    lpclm=-9.5031906e-008+dlpclmn
+ wpclm=-1.0144788e-007     ppclm=1.1495059e-013+dppclmn
+ pdiblc1=0                 pdiblc2=0.0014356508+dpdiblc2n
+ lpdiblc2=1.2276324e-010+dlpdiblc2n                  wpdiblc2=1.1503719e-010
+ ppdiblc2=-4.6733404e-017+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.22414387           lkt1=-2.3051023e-08
+ wkt1=-1.6749742e-08       pkt1=1.3890378e-14        kt1l=0
+ kt2=-0.056575902          lkt2=1.4072901e-09        wkt2=1.0898507e-09
+ pkt2=-8.457698e-16        ute=-1.2217685            lute=-4.7453698e-008
+ wute=-2.4593713e-008      pute=4.3831859e-014       ua1=3.1519588e-09
+ lua1=-1.1323604e-16       wua1=-1.2006387e-16       pua1=-2.160726e-23
+ ub1=-3.4530876e-018       lub1=-2.3718997e-025      wub1=-4.2859905e-025
+ pub1=4.3276244e-031       uc1=1.2806939e-10         luc1=-6.5150827e-17
+ wuc1=-8.7940302e-17       puc1=5.8895201e-23        prt=0
+ at=96837.304              lat=-0.030045576          wat=0.006826252
+ pat=-7.914429e-09         jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
     12: type=n 
+ lmin=1.8e-07              lmax=5e-007-dxln          wmin=5.3e-007-dxwn
+ wmax=1.23e-006-dxwn       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.45100766+dvthn     lvth0=-1.8312768e-009+dlvthn
+ wvth0=1.2033323e-008+dwvthn                         pvth0=-1.0621851e-015+dpvthn
+ k1=0.448                  k2=0.038163914+dk2        lk2=1.4576788e-009+dlk2
+ wk2=-1.6538724e-009       pk2=-5.0413351e-016       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035            lkvth0we=-1.4299999e-010  wkvth0we=-1.1999982e-011
+ pkvth0we=1.4999994e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.000449348+dcitn     lcit=-5.2902299e-011+dlcitn
+ wcit=2.5812259e-011       pcit=2.6959011e-017+dpcitn
+ voff=-0.12170577+dvoffn   tvoff=0.001750652         ptvoff=-2.6959012e-17
+ wtvoff=-2.5812261e-11     ltvoff=5.2902302e-11      lvoff=2.6284605e-010+dlvoffn
+ wvoff=-2.2401838e-008     pvoff=5.3378843e-016+dpvoffn
+ nfactor=1.3456            wnfactor=-1.7611776e-007  eta0=0.34772908+deta0n
+ leta0=4.7185912e-009+dleta0n                        weta0=-9.6593161e-009
+ peta0=-1.3169477e-014+dpeta0n                       etab=-0.308
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.03277883+du0n
+ lu0=2.5706843e-010+dlu0n  wu0=5.1201478e-010        pu0=-1.3708657e-016+dpu0n
+ ua=-4.8910711e-010        lua=-5.0449016e-017       wua=-8.4429657e-017
+ pua=1.5926036e-023        ub=1.3163084e-018         lub=1.4586584e-025
+ wub=4.5473991e-025        pub=-7.4676462e-032       uc=1.0368654e-010
+ luc=1.4815632e-017        wuc=3.0160177e-017        puc=-8.4705214e-024
+ vsat=61090.882+dvsatn     lvsat=0.00095932931+dlvsatn
+ wvsat=0.010850899         pvsat=-1.0302386e-009+dpvsatn
+ a0=0.75505102+da0n        la0=1.7639096e-008+dla0n  wa0=3.8847114e-008
+ pa0=7.7668912e-015+dpa0n  ags=1.0232614             lags=-3.0163421e-008
+ wags=2.4724421e-007       pags=-3.4428006e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.10179985          lketa=5.9032598e-009      wketa=7.7188011e-009
+ pketa=-2.1567209e-016     dwg=0                     dwb=0
+ pclm=0.56941084+dpclmn    lpclm=-1.782832e-008+dlpclmn
+ wpclm=1.4230381e-007      ppclm=9.381736e-015+dppclmn
+ pdiblc1=0                 pdiblc2=0.0020754301+dpdiblc2n
+ lpdiblc2=-1.5432519e-010+dlpdiblc2n                 wpdiblc2=-1.3787073e-010
+ ppdiblc2=6.2801017e-017+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.27320796           lkt1=-1.801372e-09
+ wkt1=1.734526e-08         pkt1=-8.761678e-16        kt1l=0
+ kt2=-0.052743813          lkt2=-2.523881e-10        wkt2=-1.1275252e-09
+ pkt2=1.145758e-16         ute=-1.3166839            lute=-6.3458267e-009
+ wute=7.5988759e-008       pute=2.6959011e-016       ua1=2.8231784e-09
+ lua1=2.9158718e-17        wua1=-3.8924501e-17       pua1=-5.6748718e-23
+ ub1=-3.9051406e-018       lub1=-4.1405846e-026      wub1=3.972647e-025
+ pub1=7.5080847e-032       uc1=-6.866448e-12         luc1=-6.710118e-18
+ wuc1=3.2318315e-17        puc1=6.8111944e-24        prt=0
+ at=30037.028              lat=-0.0011143775         wat=-0.014559985
+ pat=1.3479507e-09         jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     13: type=n 
+ lmin=1e-005-dxln          lmax=2e-05                wmin=2.2e-07
+ wmax=5.3e-007-dxwn        version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.45303175+dvthn     wvth0=1.5126177e-009+dwvthn
+ k1=0.448                  k2=0.049498679+dk2        wk2=-4.2651883e-009
+ k3=-3.7                   k3b=1.2                   w0=0
+ dvt0=0.09708              dvt1=0.3053               dvt2=-0.6939
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.633                minv=-0.34                voffl=-1.22e-009
+ dvtp0=1.46e-006           dvtp1=0                   lpe0=9.921e-009
+ lpeb=2.178e-008           web=0                     wec=0
+ scref=1e-006              kvth0we=0.003492826       lkvth0we=0
+ wkvth0we=-1.1247478e-011  pkvth0we=0                k2we=0.0038
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.6e-007               ngate=9e+019              ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00089942525+dcitn
+ wcit=-1.6957068e-011      voff=-0.14737457+dvoffn   tvoff=0.0016931613
+ ptvoff=0                  wtvoff=-9.8434994e-11     ltvoff=0
+ wvoff=-8.3341628e-010     nfactor=1.658695          wnfactor=-6.7723276e-008
+ eta0=0.17743427+deta0n    weta0=1.248812e-008       etab=-0.308
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.025695765+du0n
+ wu0=2.1796789e-009        ua=-7.1525143e-010        wua=1.9650906e-017
+ ub=9.9908335e-019         wub=2.689244e-025         uc=6.9611373e-011
+ wuc=5.8204612e-018        vsat=101331.99+dvsatn     wvsat=-0.0064005714
+ a0=0.96639923+da0n        wa0=7.1857545e-009        ags=0.29637191
+ wags=6.6190971e-008       a1=0                      a2=0.995
+ b0=0                      b1=0                      keta=-0.061694138
+ wketa=7.5115744e-009      dwg=0                     dwb=0
+ pclm=0.69121603+dpclmn    wpclm=-1.3971207e-008     pdiblc1=0
+ pdiblc2=0.00058465252+dpdiblc2n                     wpdiblc2=1.6100684e-010
+ pdiblcb=0                 drout=0.5                 pvag=0.6279
+ delta=0.005               pscbe1=4.5e+008           pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=90.88                 rdw=90.88                 prwg=0
+ prwb=0                    wr=1                      alpha0=1.454e-007
+ alpha1=2.295              beta0=17.8                agidl=2.593e-009
+ bgidl=1.8508e+009         cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.346
+ noff=1.973                voffcv=-0.0904            kt1=-0.23457219
+ pkt1=0                    lkt1=0                    wkt1=5.3249854e-09
+ kt1l=0                    kt2=-0.055036104          pkt2=0
+ lkt2=0                    wkt2=-2.5423e-12          ute=-1.4386321
+ wute=-2.4230528e-008      ua1=2.8643697e-09         pua1=0
+ lua1=0                    wua1=-2.6440135e-16       ub1=-4.2139758e-018
+ wub1=2.4308397e-025       uc1=-3.0422229e-011       wuc1=-1.0217634e-017
+ prt=0                     at=164968.73              pat=0
+ lat=0                     wat=-0.008359635          jss=2.85e-07
+ jsd=2.85e-07              jsws=6.9e-13              jswd=6.9e-13
+ jswgs=6.9e-13             jswgd=6.9e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn
+ cjd=cjn                   mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.202               mjswd=0.202
+ pbswgs=0.952              pbswgd=0.952              cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.541              mjswgd=0.541
+ tpb=1.49e-3               tcj=9.05e-4               tpbsw=8.94e-04
+ tcjsw=8.09e-04            tpbswg=0.00133            tcjswg=0.00088
+ xtis=3                    xtid=3                    jtsswgs=1.09e-009
+ jtsswgd=1.09e-009         njtsswg=11.6              xtsswgs=0.2886
+ xtsswgd=0.2886            tnjtsswg=1.08             vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=1.00e-05            sbref=1.00e-05
+ wlod=5e-007               kvth0=2.2e-009            lkvth0=-1e-008
+ wkvth0=2.2e-006           pkvth0=-5e-014            llodvth=1
+ wlodvth=1                 stk2=2.5e-009             lodk2=1
+ lodeta0=2                 ku0=-3.2e-008             lku0=2e-007
+ wku0=7e-007               pku0=-5e-014              llodku0=1
+ wlodku0=1                 kvsat=0.4                 steta0=-1.1e-010
+ tku0=0.03                 lvth0=0+dlvthn            pvth0=0+dpvthn
+ lk2=0+dlk2                lcit=0+dlcitn             pcit=0+dpcitn
+ lvoff=0+dlvoffn           pvoff=0+dpvoffn           leta0=0+dleta0n
+ peta0=0+dpeta0n           lu0=0+dlu0n               pu0=0+dpu0n
+ lvsat=0+dlvsatn           pvsat=0+dpvsatn           la0=0+dla0n
+ pa0=0+dpa0n               lpclm=0+dlpclmn           ppclm=0+dppclmn
+ lpdiblc2=0+dlpdiblc2n     ppdiblc2=0+dppdiblc2n     fnoimod=1
+ noia=noian                noib=noibn                noic=noicn
+ em=3.00e7                 ef=0.904                  minr=1e-3
 
 
     14: type=n 
+ lmin=1.2e-006-dxln        lmax=1e-005-dxln          wmin=2.2e-07
+ wmax=5.3e-007-dxwn        version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.45234877+dvthn     lvth0=6.7841929e-009+dlvthn
+ wvth0=1.9000387e-009+dwvthn                         pvth0=-3.8482916e-015+dpvthn
+ k1=0.448                  k2=0.049708891+dk2        lk2=-2.0880632e-009+dlk2
+ wk2=-4.2326145e-009       pk2=-3.2355865e-016       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035081523      lkvth0we=-1.5223736e-010  wkvth0we=-1.2855127e-011
+ pkvth0we=1.5968941e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00093598992+dcitn   lcit=-3.6320049e-010+dlcitn
+ wcit=-1.8126514e-011      pcit=1.1616217e-017+dpcitn
+ voff=-0.14627576+dvoffn   tvoff=0.0017294969        ptvoff=2.098306e-17
+ wtvoff=-1.0054744e-10     ltvoff=-3.6092541e-10     lvoff=-1.0914586e-008+dlvoffn
+ wvoff=-9.8720172e-010     pvoff=1.5275661e-015+dpvoffn
+ nfactor=1.7223427         lnfactor=-6.3221952e-007  wnfactor=-7.2218542e-008
+ pnfactor=4.4651933e-014   eta0=0.18419492+deta0n    leta0=-6.7154174e-008+dleta0n
+ weta0=1.1138695e-008      peta0=1.3403973e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.025734547+du0n       lu0=-3.8522805e-010+dlu0n wu0=2.1923957e-009
+ pu0=-1.2631797e-016+dpu0n ua=-7.4834311e-010        lua=3.2870292e-016
+ wua=2.8374005e-017        pua=-8.6647412e-023       ub=1.0002368e-018
+ lub=-1.145736e-026        wub=2.8138778e-025        pub=-1.238e-031
+ uc=6.3534915e-011         luc=6.0358059e-017        wuc=6.8732577e-018
+ puc=-1.0457533e-023       vsat=104447.26+dvsatn     lvsat=-0.030944327+dlvsatn
+ wvsat=-0.0070415271       pvsat=6.3666774e-009+dpvsatn
+ a0=1.0509621+da0n         la0=-8.3997116e-007+dla0n wa0=-1.374343e-008
+ pa0=2.0789168e-013+dpa0n  ags=0.23996998            lags=5.6024604e-007
+ wags=6.9895341e-008       pags=-3.6795879e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.061786008         lketa=9.1255707e-010      wketa=8.6900186e-009
+ pketa=-1.1705605e-014     dwg=0                     dwb=0
+ pclm=0.69474615+dpclmn    lpclm=-3.5065083e-008+dlpclmn
+ wpclm=-1.5770158e-008     ppclm=1.7869166e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0004881786+dpdiblc2n
+ lpdiblc2=9.5828501e-010+dlpdiblc2n                  wpdiblc2=1.5845079e-010
+ ppdiblc2=2.5389492e-017+dppdiblc2n                  pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.23046948           lkt1=-4.0752482e-08
+ wkt1=5.1487626e-09        pkt1=1.750431e-15         kt1l=0
+ kt2=-0.055121839          lkt2=8.516152e-10         wkt2=1.614237e-11
+ pkt2=-1.855959e-16        ute=-1.4614899            lute=2.270494e-007
+ wute=-2.8998185e-008      pute=4.7357614e-014       ua1=2.8633408e-09
+ lua1=1.022118e-17         wua1=-2.9231996e-16       pua1=2.7731835e-22
+ ub1=-4.2552952e-018       lub1=4.1043047e-025       wub1=2.6525806e-025
+ pub1=-2.2025749e-031      uc1=-3.4311091e-011       luc1=3.8628462e-017
+ wuc1=-1.1547715e-017      puc1=1.321183e-023        prt=0
+ at=177197.4               lat=-0.12146865           wat=-0.0094368784
+ pat=1.0700365e-08         jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     15: type=n 
+ lmin=5e-007-dxln          lmax=1.2e-006-dxln        wmin=2.2e-07
+ wmax=5.3e-007-dxwn        version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.44828089+dvthn     lvth0=1.1393503e-008+dlvthn
+ wvth0=4.181767e-010+dwvthn                          pvth0=-2.1691937e-015+dpvthn
+ k1=0.448                  k2=0.048140709+dk2        lk2=-3.1115533e-010+dlk2
+ wk2=-3.7122147e-009       pk2=-9.1322366e-016       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035            lkvth0we=-1.4299999e-010  wkvth0we=-1.2000011e-011
+ pkvth0we=1.5000009e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00048769918+dcitn   lcit=1.4475774e-010+dlcitn
+ wcit=8.8758178e-011       pcit=-1.0949483e-016+dpcitn
+ voff=-0.14850048+dvoffn   tvoff=0.00095327882       ptvoff=-1.0351402e-16
+ wtvoff=9.32555e-12        ltvoff=5.1860729e-10      lvoff=-8.3937491e-009+dlvoffn
+ wvoff=-1.0682653e-009     pvoff=1.6194193e-015+dpvoffn
+ nfactor=1.305933          lnfactor=-1.6038562e-007  wnfactor=-7.3413756e-008
+ pnfactor=4.6006229e-014   eta0=0.0092251498+deta0n  leta0=1.3110407e-007+dleta0n
+ weta0=4.7248216e-008      peta0=-2.7511725e-014+dpeta0n
+ etab=-0.308               ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.020914402+du0n       lu0=5.0764788e-009+dlu0n  wu0=3.0151699e-009
+ pu0=-1.0586033e-015+dpu0n ua=-4.7450936e-010        lua=1.8421903e-017
+ wua=6.3743975e-018        pua=-6.1719657e-023       ub=3.3755544e-019
+ lub=7.394269e-025         wub=2.2747064e-025        pub=-6.2706491e-032
+ uc=4.6796853e-011         luc=7.9323958e-017        wuc=1.8651644e-017
+ puc=-2.3803623e-023       vsat=77860.433+dvsatn     lvsat=-0.00081878711+dlvsatn
+ wvsat=-0.0035518874       pvsat=2.4125667e-009+dpvsatn
+ a0=-0.10275458+da0n       la0=4.6730518e-007+dla0n  wa0=2.9650415e-007
+ pa0=-1.4364985e-013+dpa0n ags=0.3065495             lags=4.8480478e-007
+ wags=1.0570427e-007       pags=-7.7370976e-014      a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.044479894         lketa=-1.8697001e-008     wketa=-6.9594572e-009
+ pketa=6.0268161e-015      dwg=0                     dwb=0
+ pclm=0.4744185+dpclmn     lpclm=2.1458817e-007+dlpclmn
+ wpclm=3.7800547e-008      ppclm=-4.28318e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0015597345+dpdiblc2n
+ lpdiblc2=-2.5589493e-010+dlpdiblc2n                 wpdiblc2=5.1804148e-011
+ ppdiblc2=1.462308e-016+dppdiblc2n                   pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.27879193           lkt1=1.4001673e-08
+ wkt1=1.1098907e-08        pkt1=-4.991675e-15        kt1l=0
+ kt2=-0.053872644          lkt2=-5.638463e-10        wkt2=-2.877297e-10
+ pkt2=1.587215e-16         ute=-1.3891561            lute=1.4508792e-007
+ wute=6.0707017e-008       pute=-5.4287351e-014      ua1=2.6364413e-09
+ lua1=2.6732108e-16        wua1=1.4264386e-16        pua1=-2.1553916e-22
+ ub1=-4.1547516e-018       lub1=2.9650447e-025       wub1=-7.1031093e-026
+ pub1=1.6079175e-031       uc1=-4.151591e-011        luc1=4.6792241e-017
+ wuc1=-1.519636e-018       puc1=1.8490137e-024       prt=0
+ at=114195.88              lat=-0.050081619          wat=-0.0020196821
+ pat=2.2959393e-09         jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
 
     16: type=n 
+ lmin=1.8e-07              lmax=5e-007-dxln          wmin=2.2e-07
+ wmax=5.3e-007-dxwn        version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn                 toxm=toxn
+ dtox=5.958e-010           epsrox=3.9                wint=1.02e-008
+ lint=2.595e-008           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln
+ xw=0+dxwn                 dlc=2.595e-008+dlcn       dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.48719013+dvthn     lvth0=-5.4580876e-009+dlvthn
+ wvth0=-6.4052624e-009+dwvthn                        pvth0=7.8603777e-016+dpvthn
+ k1=0.448                  k2=0.04626793+dk2         lk2=4.9994489e-010+dlk2
+ wk2=-5.7836793e-009       pk2=-1.6072338e-017       k3=-3.7
+ k3b=1.2                   w0=0                      dvt0=0.09708
+ dvt1=0.3053               dvt2=-0.6939              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.633
+ minv=-0.34                voffl=-1.22e-009          dvtp0=1.46e-006
+ dvtp1=0                   lpe0=9.921e-009           lpeb=2.178e-008
+ web=0                     wec=0                     scref=1e-006
+ kvth0we=0.0035            lkvth0we=-1.4299999e-010  wkvth0we=-1.1999981e-011
+ pkvth0we=1.4999996e-017   k2we=0.0038               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.6e-007
+ ngate=9e+019              ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00082193549+dcitn   lcit=-1.2910146e-018+dlcitn
+ wcit=-1.6405833e-010      pcit=6.5790105e-025+dpcitn
+ voff=-0.17614288+dvoffn   tvoff=0.0021962234        ptvoff=1.0045211e-17
+ wtvoff=-2.528754e-10      ltvoff=-1.9711953e-11     lvoff=3.5781717e-009+dlvoffn
+ wvoff=5.3393099e-009      pvoff=-1.1557015e-015+dpvoffn
+ nfactor=0.85596405        lnfactor=3.4495917e-008   wnfactor=7.3400719e-008
+ pnfactor=-1.7579119e-014  eta0=0.39703025+deta0n    leta0=-3.685432e-008+dleta0n
+ weta0=-3.4783194e-008     peta0=8.0160785e-015+dpeta0n
+ etab=-0.24211447          letab=-2.8535023e-008     wetab=-3.3575266e-008
+ petab=1.4541448e-014      ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.033118824+du0n       lu0=-2.092564e-010+dlu0n  wu0=3.3875357e-010
+ pu0=1.0055256e-016+dpu0n  ua=-3.335318e-010         lua=-4.263548e-017
+ wua=-1.6371084e-016       pua=1.1944258e-023        ub=1.9040785e-018
+ lub=6.0965752e-026        wub=1.5521224e-025        pub=-3.1411375e-032
+ uc=2.2466359e-010         luc=2.2898732e-018        wuc=-3.1489728e-017
+ puc=-2.0873949e-024       vsat=81637.162+dvsatn     lvsat=-0.0024544887+dlvsatn
+ wvsat=0.00038051534       pvsat=7.0944303e-010+dpvsatn
+ a0=0.85142296+da0n        la0=5.4050885e-008+dla0n  wa0=-1.0264022e-008
+ pa0=-1.0788557e-014+dpa0n ags=1.7021554             lags=-1.1963214e-007
+ wags=-9.8720178e-008      pags=1.1165252e-014       a1=0
+ a2=0.995                  b0=0                      b1=0
+ keta=-0.10549168          lketa=7.727204e-009       wketa=9.6001598e-009
+ pketa=-1.1451541e-015     dwg=0                     dwb=0
+ pclm=0.93788546+dpclmn    lpclm=1.3860637e-008+dlpclmn
+ wpclm=-4.5470853e-008     ppclm=-6.7669565e-015+dppclmn
+ pdiblc1=0                 pdiblc2=0.00072159941+dpdiblc2n
+ lpdiblc2=1.0710136e-010+dlpdiblc2n                  wpdiblc2=5.520414e-010
+ ppdiblc2=-7.0421953e-017+dppdiblc2n                 pdiblcb=0
+ drout=0.5                 pvag=0.6279               delta=0.005
+ pscbe1=4.5e+008           pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=90.88
+ rdw=90.88                 prwg=0                    prwb=0
+ wr=1                      alpha0=1.454e-007         alpha1=2.295
+ beta0=17.8                agidl=2.593e-009          bgidl=1.8508e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5.346                noff=1.973
+ voffcv=-0.0904            kt1=-0.23125654           lkt1=-6.5859059e-09
+ wkt1=-4.0331791e-09       pkt1=1.5620304e-15        kt1l=0
+ kt2=-0.055033537          lkt2=-6.10637e-11         wkt2=3.93187e-11
+ pkt2=1.707685e-17         ute=-0.98679314           lute=-2.9175468e-008
+ wute=-9.2123567e-008      pute=1.1903575e-014       ua1=3.5950246e-09
+ lua1=-1.478414e-16        wua1=-4.3225733e-16       pua1=3.3450547e-23
+ ub1=-3.6926465e-018       lub1=9.636675e-026        wub1=2.8897772e-025
+ pub1=4.8719324e-033       uc1=5.5143893e-011        luc1=4.9288809e-018
+ wuc1=7.1784539e-019       puc1=8.7996049e-025       prt=0
+ at=-6339.3589             lat=0.0021221942          wat=0.0039774212
+ pat=-3.0140637e-10        jss=2.85e-07              jsd=2.85e-07
+ jsws=6.9e-13              jswd=6.9e-13              jswgs=6.9e-13
+ jswgd=6.9e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn                   cjd=cjn
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.202               mjswd=0.202               pbswgs=0.952
+ pbswgd=0.952              cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.541              mjswgd=0.541              tpb=1.49e-3
+ tcj=9.05e-4               tpbsw=8.94e-04            tcjsw=8.09e-04
+ tpbswg=0.00133            tcjswg=0.00088            xtis=3
+ xtid=3                    jtsswgs=1.09e-009         jtsswgd=1.09e-009
+ njtsswg=11.6              xtsswgs=0.2886            xtsswgd=0.2886
+ tnjtsswg=1.08             vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=1.00e-05
+ sbref=1.00e-05            ngcon=1                   wlod=5e-007
+ kvth0=2.2e-009            lkvth0=-1e-008            wkvth0=2.2e-006
+ pkvth0=-5e-014            llodvth=1                 wlodvth=1
+ stk2=2.5e-009             lodk2=1                   lodeta0=2
+ ku0=-3.2e-008             lku0=2e-007               wku0=7e-007
+ pku0=-5e-014              llodku0=1                 wlodku0=1
+ kvsat=0.4                 steta0=-1.1e-010          tku0=0.03
+ fnoimod=1                 noia=noian                noib=noibn
+ noic=noicn                em=3.00e7                 ef=0.904
+ minr=1e-3
 
// *********************************************************************************************
//                                                                            
//                   *
//                                1.8V STD-VT PMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
     } 
model pch bsim4  { 
     1: type=p 
+ lmin=1e-005-dxlp          lmax=2e-05                wmin=1.003e-005-dxwp
+ wmax=90.003e-05           version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.459+dvthp         k1=0.493
+ k2=0.04632+dk2p           k3=-2.62                  k3b=2.309
+ w0=0                      dvt0=9.8                  dvt1=2
+ dvt2=-0.1768              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.7                  minv=-0.536
+ voffl=-4.64e-009          dvtp0=0                   dvtp1=0
+ lpe0=5.86e-008            lpeb=8e-009               web=-500
+ wec=0                     scref=1e-006              kvth0we=-0.0055034962
+ lkvth0we=0                wkvth0we=0                pkvth0we=0
+ k2we=0.0023               lk2we=0                   wk2we=0
+ pk2we=0                   xj=1.5e-007               ngate=6.7045e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-1.6805e-013          voff=-0.12508+dvoffp      nfactor=1
+ eta0=0.189                tvoff=0.0035              ptvoff=0
+ wtvoff=0                  ltvoff=0                  etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.013907+du0p          ua=1.5887e-009
+ ub=1.478e-018             uc=1.058e-011             vsat=92640
+ a0=1.2107                 ags=0.456+dagsp           a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.0334              dwg=0                     dwb=0
+ pclm=0.491                pdiblc1=0                 pdiblc2=0.000575
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.175
+ pkt1=0                    wkt1=0                    lkt1=0
+ kt1l=0                    kt2=-0.045                pkt2=0
+ wkt2=0                    lkt2=0                    ute=-1.121
+ ua1=2.479e-09             pua1=0                    wua1=0
+ lua1=0                    ub1=-5.53e-018            uc1=1.751e-11
+ puc1=0                    wuc1=0                    luc1=0
+ prt=0                     at=117200                 jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   saref=1.00e-05
+ sbref=1.00e-05            rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lvth0=0+dlvthp            wvth0=0+dwvthp
+ lk2=0+dlk2p               wk2=0+dwk2p               lcit=0+dlcitp
+ wcit=0+dwcitp             pcit=0+dpcitp             lvoff=0+dlvoffp
+ wvoff=0+dwvoffp           pvoff=0+dpvoffp           lnfactor=0+dlnfactorp
+ lu0=0+dlu0p               wu0=0+dwu0p               lvsat=0+dlvsatp
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           lpclm=0+dlpclmp
+ wpclm=0+dwpclmp           ppclm=0+dppclmp           lpdiblc2=0+dlpdiblc2p
+ wpdiblc2=0+dwpdiblc2p     ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     2: type=p 
+ lmin=1.2e-006-dxlp        lmax=1e-005-dxlp          wmin=1.003e-005-dxwp
+ wmax=90.003e-05           version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.45586545+dvthp    lvth0=-3.1088821e-008+dlvthp
+ k1=0.493                  k2=0.045966903+dk2p       lk2=3.5020605e-009+dlk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0055098244     lkvth0we=6.2763377e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=3.2262844e-005
+ lcit=-3.1998676e-010+dlcitp                         voff=-0.12431637+dvoffp
+ tvoff=0.0035635296        ptvoff=0                  wtvoff=0
+ ltvoff=-6.3009366e-10     lvoff=-7.5737257e-009+dlvoffp
+ nfactor=0.95552932        lnfactor=4.4106556e-007+dlnfactorp
+ eta0=0.189                etab=-0.0159              ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.013958713+du0p       lu0=-5.1289624e-010+dlu0p ua=1.5084622e-009
+ lua=7.9580829e-016        ub=1.6295319e-018         lub=-1.502912e-024
+ uc=1.3911489e-011         luc=-3.3042111e-017       vsat=91133.079
+ lvsat=0.014945822+dlvsatp a0=1.2697291              la0=-5.8545782e-007
+ ags=0.48090104+dagsp      lags=-2.4697151e-007      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.0334              dwg=0                     dwb=0
+ pclm=0.48975228           lpclm=1.2375039e-008+dlpclmp
+ pdiblc1=0                 pdiblc2=0.00037857935     lpdiblc2=1.9481236e-009+dlpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.173488
+ pkt1=0                    wkt1=0                    lkt1=-1.499623e-08
+ kt1l=0                    kt2=-0.045                pkt2=0
+ wkt2=0                    lkt2=0                    ute=-1.131673
+ lute=1.0585573e-007       ua1=2.4046704e-09         pua1=0
+ wua1=0                    lua1=7.3720958e-16        ub1=-5.4265739e-018
+ lub1=-1.0257925e-024      uc1=3.0503065e-11         puc1=0
+ wuc1=0                    luc1=-1.2886676e-16       prt=0
+ at=114303.05              pat=0                     wat=0
+ lat=0.028732271           jss=1.76e-07              jsd=1.76e-07
+ jsws=2.71e-13             jswd=2.71e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.2                  bvd=10.2
+ xjbvs=1                   xjbvd=1                   pbs=0.86
+ pbd=0.86                  cjs=cjp                   cjd=cjp
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswp               cjswd=cjswp
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.45765            mjswgd=0.45765            tpb=0.00161
+ tcj=0.000918              tpbsw=0.00125             tcjsw=0.000886
+ tpbswg=0.00115            tcjswg=0.000723           xtis=3
+ xtid=3                    jtsswgs=6.5702e-011       jtsswgd=6.5702e-011
+ njtsswg=7.1               xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             rshg=8.41                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   saref=1.00e-05            sbref=1.00e-05
+ rbsb=50                   ngcon=1                   wlod=5e-006
+ kvth0=-2.3e-009           lkvth0=1e-008             wkvth0=2.5e-007
+ pkvth0=4e-014             llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=5.54e-008             lku0=5e-008               wku0=1e-008
+ pku0=1e-014               llodku0=1                 wlodku0=1
+ kvsat=-0.6                steta0=0                  tku0=0.5
+ wvth0=0+dwvthp            wk2=0+dwk2p               wcit=0+dwcitp
+ pcit=0+dpcitp             wvoff=0+dwvoffp           pvoff=0+dpvoffp
+ wu0=0+dwu0p               wvsat=0+dwvsatp           pvsat=0+dpvsatp
+ wpclm=0+dwpclmp           ppclm=0+dppclmp           wpdiblc2=0+dwpdiblc2p
+ ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p           weta0=0+dweta0p
+ peta0=0+dpeta0p           fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     3: type=p 
+ lmin=5e-007-dxlp          lmax=1.2e-006-dxlp        wmin=1.003e-005-dxwp
+ wmax=90.003e-05           version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.48365805+dvthp    lvth0=-1.3357381e-011+dlvthp
+ k1=0.493                  k2=0.047992177+dk2p       lk2=1.2375613e-009+dlk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0055098242     lkvth0we=6.2763261e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00064690501
+ lcit=4.394044e-010+dlcitp voff=-0.13413033+dvoffp   tvoff=0.0027013429
+ ptvoff=0                  wtvoff=0                  ltvoff=3.3393452e-10
+ lvoff=3.3994535e-009+dlvoffp                        nfactor=1.55906
+ lnfactor=-2.3375417e-007+dlnfactorp                 eta0=0.189
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.012394969+du0p
+ lu0=1.2355577e-009+dlu0p  ua=2.4998028e-009         lua=-3.126295e-016
+ ub=-1.1381951e-018        lub=1.591739e-024         uc=-1.0779365e-010
+ luc=1.0303884e-016        vsat=90863.315            lvsat=0.01524745+dlvsatp
+ a0=0.40572253             la0=3.8060521e-007        ags=-0.10427601+dagsp
+ lags=4.0732665e-007       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.0099231593
+ lketa=-2.6249925e-008     dwg=0                     dwb=0
+ pclm=0.50668563           lpclm=-6.5584741e-009+dlpclmp
+ pdiblc1=0                 pdiblc2=0.0018138207      lpdiblc2=3.4335148e-010+dlpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.1920369
+ pkt1=0                    wkt1=0                    lkt1=5.743673e-09
+ kt1l=0                    kt2=-0.045                pkt2=0
+ wkt2=0                    lkt2=-1e-16               ute=-1.0607134
+ lute=2.6514388e-008       ua1=3.2772412e-09         pua1=0
+ wua1=0                    lua1=-2.3842925e-16       ub1=-6.908462e-018
+ lub1=6.3113625e-025       uc1=-1.5807032e-10        puc1=0
+ wuc1=0                    luc1=8.1980922e-17        prt=0
+ at=170725.85              pat=0                     wat=0
+ lat=-0.034355184          jss=1.76e-07              jsd=1.76e-07
+ jsws=2.71e-13             jswd=2.71e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.2                  bvd=10.2
+ xjbvs=1                   xjbvd=1                   pbs=0.86
+ pbd=0.86                  cjs=cjp                   cjd=cjp
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswp               cjswd=cjswp
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.45765            mjswgd=0.45765            tpb=0.00161
+ tcj=0.000918              tpbsw=0.00125             tcjsw=0.000886
+ tpbswg=0.00115            tcjswg=0.000723           xtis=3
+ xtid=3                    jtsswgs=6.5702e-011       jtsswgd=6.5702e-011
+ njtsswg=7.1               xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             rshg=8.41                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   saref=1.00e-05            sbref=1.00e-05
+ rbsb=50                   ngcon=1                   wlod=5e-006
+ kvth0=-2.3e-009           lkvth0=1e-008             wkvth0=2.5e-007
+ pkvth0=4e-014             llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=5.54e-008             lku0=5e-008               wku0=1e-008
+ pku0=1e-014               llodku0=1                 wlodku0=1
+ kvsat=-0.6                steta0=0                  tku0=0.5
+ wvth0=0+dwvthp            wk2=0+dwk2p               wcit=0+dwcitp
+ pcit=0+dpcitp             wvoff=0+dwvoffp           pvoff=0+dpvoffp
+ wu0=0+dwu0p               wvsat=0+dwvsatp           pvsat=0+dpvsatp
+ wpclm=0+dwpclmp           ppclm=0+dppclmp           wpdiblc2=0+dwpdiblc2p
+ ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p           weta0=0+dweta0p
+ peta0=0+dpeta0p           fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     4: type=p 
+ lmin=1.8e-07              lmax=5e-007-dxlp          wmin=1.003e-005-dxwp
+ wmax=90.003e-05           version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.48927671+dvthp    lvth0=2.3359141e-009+dlvthp
+ k1=0.493                  k2=0.052087126+dk2p       lk2=-4.7461878e-010+dlk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0055098244     lkvth0we=6.2763333e-011
+ wkvth0we=0                pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0002212515
+ lcit=7.6410803e-011+dlcitp                          voff=-0.12935141+dvoffp
+ tvoff=0.0035              ptvoff=0                  wtvoff=0
+ ltvoff=0                  lvoff=1.4012921e-009+dlvoffp
+ nfactor=1                 eta0=0.189                etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.014616246+du0p       lu0=3.0679707e-010+dlu0p
+ ua=1.8886708e-009         lua=-5.7102972e-017       ub=2.4383326e-018
+ lub=9.6321202e-026        uc=1.980118e-010          luc=-2.4824536e-017
+ vsat=142095.83            lvsat=-0.0061738903+dlvsatp
+ a0=1.316                  ags=0.99093795+dagsp      lags=-5.0604208e-008
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.084755589         lketa=5.0390104e-009
+ dwg=0                     dwb=0                     pclm=0.50605529
+ lpclm=-6.2949168e-009+dlpclmp                       pdiblc1=0
+ pdiblc2=0.0028326811      lpdiblc2=-8.2654437e-011+dlpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.17685886
+ pkt1=0                    wkt1=0                    lkt1=-6.02568e-10
+ kt1l=0                    kt2=-0.045                pkt2=0
+ wkt2=0                    lkt2=1e-16                ute=-1.0326539
+ pute=0                    wute=0                    lute=1.478216e-08
+ ua1=2.7577465e-09         pua1=0                    wua1=0
+ lua1=-2.12181e-17         ub1=-5.8792974e-18        pub1=0
+ wub1=0                    lub1=2.0082195e-25        uc1=3.8797215e-11
+ puc1=0                    wuc1=0                    luc1=-3.33335e-19
+ prt=0                     at=111115.34              pat=0
+ wat=0                     lat=-0.0094308368         jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   saref=1.00e-05
+ sbref=1.00e-05            rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  wvth0=0+dwvthp            wk2=0+dwk2p
+ wcit=0+dwcitp             pcit=0+dpcitp             wvoff=0+dwvoffp
+ pvoff=0+dpvoffp           lnfactor=0+dlnfactorp     wu0=0+dwu0p
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           wpclm=0+dwpclmp
+ ppclm=0+dppclmp           wpdiblc2=0+dwpdiblc2p     ppdiblc2=0+dppdiblc2p
+ leta0=0+dleta0p           weta0=0+dweta0p           peta0=0+dpeta0p
+ fnoimod=1                 noia=noiap                noib=noibp
+ noic=noicp                em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     5: type=p 
+ lmin=1e-005-dxlp          lmax=2e-05                wmin=1.23e-006-dxwp
+ wmax=1.003e-005-dxwp      version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.45773606+dvthp    wvth0=-1.2736721e-008+dwvthp
+ k1=0.493                  k2=0.045916729+dk2p       wk2=4.0637598e-009+dwk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.0054941521     lkvth0we=0
+ wkvth0we=-9.4160342e-011  pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-1.4511364e-005
+ wcit=1.4623101e-010+dwcitp                          voff=-0.12477236+dvoffp
+ tvoff=0.0035              ptvoff=0                  wtvoff=0
+ ltvoff=0                  wvoff=-3.1000974e-009+dwvoffp
+ nfactor=1                 eta0=0.189                etab=-0.01703058
+ wetab=1.1392858e-008      ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.013868835+du0p
+ wu0=3.8458756e-010+dwu0p  ua=1.5206127e-009         wua=6.8611591e-016
+ ub=1.5710004e-018         wub=-9.3716531e-025       uc=2.2020759e-011
+ wuc=-1.1528853e-016       vsat=92640                a0=1.2385473
+ wa0=-2.8061731e-007       ags=0.47029369+dagsp      wags=-1.4403755e-007
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.0334              dwg=0
+ dwb=0                     pclm=0.491                pdiblc1=0
+ pdiblc2=0.00062941761     wpdiblc2=-5.4836629e-010+dwpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.17642211
+ pkt1=0                    lkt1=0                    wkt1=1.433064e-08
+ kt1l=0                    kt2=-0.044986939          pkt2=0
+ lkt2=0                    wkt2=-1.316078e-10        ute=-1.1214353
+ wute=4.3869303e-009       ua1=2.4855736e-09         pua1=0
+ lua1=0                    wua1=-6.624265e-17        ub1=-5.5369655e-018
+ wub1=7.0190885e-026       uc1=3.2459606e-11         puc1=0
+ luc1=0                    wuc1=-1.5064719e-16       prt=0
+ at=116793.69              pat=0                     lat=0
+ wat=0.0040944683          jss=1.76e-07              jsd=1.76e-07
+ jsws=2.71e-13             jswd=2.71e-13             jswgs=1e-12
+ jswgd=1e-12               njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10.2                  bvd=10.2
+ xjbvs=1                   xjbvd=1                   pbs=0.86
+ pbd=0.86                  cjs=cjp                   cjd=cjp
+ mjs=0.44                  mjd=0.44                  pbsws=0.6
+ pbswd=0.6                 cjsws=cjswp               cjswd=cjswp
+ mjsws=0.338               mjswd=0.338               pbswgs=0.95
+ pbswgd=0.95               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.45765            mjswgd=0.45765            tpb=0.00161
+ tcj=0.000918              tpbsw=0.00125             tcjsw=0.000886
+ tpbswg=0.00115            tcjswg=0.000723           xtis=3
+ xtid=3                    jtsswgs=6.5702e-011       jtsswgd=6.5702e-011
+ njtsswg=7.1               xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=0                vtsswgs=10                vtsswgd=10
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.3e-008             rshg=8.41                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   saref=1.00e-05            sbref=1.00e-05
+ rbsb=50                   ngcon=1                   wlod=5e-006
+ kvth0=-2.3e-009           lkvth0=1e-008             wkvth0=2.5e-007
+ pkvth0=4e-014             llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=5.54e-008             lku0=5e-008               wku0=1e-008
+ pku0=1e-014               llodku0=1                 wlodku0=1
+ kvsat=-0.6                steta0=0                  tku0=0.5
+ lvth0=0+dlvthp            lk2=0+dlk2p               lcit=0+dlcitp
+ pcit=0+dpcitp             lvoff=0+dlvoffp           pvoff=0+dpvoffp
+ lnfactor=0+dlnfactorp     lu0=0+dlu0p               lvsat=0+dlvsatp
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           lpclm=0+dlpclmp
+ wpclm=0+dwpclmp           ppclm=0+dppclmp           lpdiblc2=0+dlpdiblc2p
+ ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p           weta0=0+dweta0p
+ peta0=0+dpeta0p           fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     6: type=p 
+ lmin=1.2e-006-dxlp        lmax=1e-005-dxlp          wmin=1.23e-006-dxwp
+ wmax=1.003e-005-dxwp      version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.45427553+dvthp    lvth0=-3.4321969e-008+dlvthp
+ wvth0=-1.6021661e-008+dwvthp                        pvth0=3.2580433e-014
+ k1=0.493                  k2=0.045549508+dk2p       lk2=3.6421392e-009+dlk2p
+ wk2=4.2060824e-009+dwk2p  pk2=-1.411573e-015        k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055           lkvth0we=5.8000061e-011   wkvth0we=-9.8999962e-011
+ pkvth0we=4.7999933e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=2.0589458e-005        lcit=-3.4813417e-010+dlcitp
+ wcit=1.1763271e-010+dwcitp                          pcit=2.8364141e-016+dpcitp
+ voff=-0.12396872+dvoffp   tvoff=0.0035727486        ptvoff=9.2139232e-16
+ wtvoff=-9.2899897e-11     ltvoff=-7.2152884e-10     lvoff=-7.9705544e-009+dlvoffp
+ wvoff=-3.503283e-009+dwvoffp                        pvoff=3.9988427e-015+dpvoffp
+ nfactor=0.94907602        lnfactor=5.0507019e-007+dlnfactorp
+ wnfactor=6.5029928e-008   pnfactor=-6.4497463e-013  eta0=0.189
+ etab=-0.017174231         letab=1.424743e-009       wetab=1.2840424e-008
+ petab=-1.4357135e-014     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.013937714+du0p
+ lu0=-6.8314854e-010+dlu0p wu0=2.1160795e-010+dwu0p  pu0=1.7156325e-015
+ ua=1.4324742e-009         lua=8.7416824e-016        wua=7.6573112e-016
+ pua=-7.8963322e-022       ub=1.7521381e-018         lub=-1.7965451e-024
+ wub=-1.2355022e-024       pub=2.9589409e-030        uc=2.621865e-011
+ luc=-4.163519e-017        wuc=-1.2401926e-016       puc=8.6592451e-023
+ vsat=91013.97             lvsat=0.016127164+dlvsatp wvsat=0.0012002667+dwvsatp
+ pvsat=-1.1904389e-008+dpvsatp                       a0=1.3116221
+ la0=-7.2476481e-007       wa0=-4.2215588e-007       pa0=1.4037965e-012
+ ags=0.50246724+dagsp      lags=-3.1910107e-007      wags=-2.1732256e-007
+ pags=7.2684955e-013       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.033780265
+ lketa=3.7715184e-009      wketa=3.8319349e-009      pketa=-3.8005591e-014
+ dwg=0                     dwb=0                     pclm=0.48957122
+ lpclm=1.4170826e-008+dlpclmp                        wpclm=1.824554e-009+dwpclmp
+ ppclm=-1.8096145e-014+dppclmp                       pdiblc1=0
+ pdiblc2=0.00044934226     lpdiblc2=1.786009e-009+dlpdiblc2p
+ wpdiblc2=-7.1307781e-010+dwpdiblc2p                 ppdiblc2=1.6336286e-015+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.17468516
+ lkt1=-1.7227243e-08       wkt1=1.2063879e-08        pkt1=2.248198e-14
+ kt1l=0                    kt2=-0.04498528           lkt2=-1.64576e-11
+ wkt2=-1.483305e-10        pkt2=1.65851e-16          ute=-1.1309596
+ lute=9.4462912e-008       wute=-7.1883949e-009      pute=1.1480547e-013
+ ua1=2.4185049e-09         lua1=6.6519523e-16        wua1=-1.3941061e-16
+ pua1=7.2568863e-22        ub1=-5.4458191e-018       lub1=-9.0400081e-025
+ wub1=1.9393355e-025       pub1=-1.2272946e-030      uc1=4.7456325e-11
+ luc1=-1.4873928e-16       wuc1=-1.7083805e-16       puc1=2.002554e-22
+ prt=0                     at=113660.72              lat=0.031073012
+ wat=0.006472708           pat=-2.358767e-08         jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ saref=1.00e-05            sbref=1.00e-05            rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  leta0=0+dleta0p           weta0=0+dweta0p
+ peta0=0+dpeta0p           fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     7: type=p 
+ lmin=5e-007-dxlp          lmax=1.2e-006-dxlp        wmin=1.23e-006-dxwp
+ wmax=1.003e-005-dxwp      version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.48524403+dvthp    lvth0=3.0453007e-010+dlvthp
+ wvth0=1.5981866e-008+dwvthp                         pvth0=-3.2033519e-015
+ k1=0.493                  k2=0.047324832+dk2p       lk2=1.6571146e-009+dlk2p
+ wk2=6.7248331e-009+dwk2p  pk2=-4.2278385e-015       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054999999     lkvth0we=5.7999931e-011   wkvth0we=-9.9000092e-011
+ pkvth0we=4.8000079e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00076158258        lcit=5.2642803e-010+dlcitp
+ wcit=1.1556058e-009+dwcitp                          pcit=-8.769371e-016+dpcitp
+ voff=-0.13429534+dvoffp   tvoff=0.0025854468        ptvoff=-4.8831583e-16
+ wtvoff=1.1678844e-09      ltvoff=3.8239298e-10      lvoff=3.5758422e-009+dlvoffp
+ wvoff=1.6628104e-009+dwvoffp                        pvoff=-1.7774696e-015+dpvoffp
+ nfactor=1.6401872         lnfactor=-2.6767508e-007+dlnfactorp
+ wnfactor=-8.1751909e-007  pnfactor=3.4182108e-013   eta0=0.18719796
+ leta0=2.0149025e-009+dleta0p                        weta0=1.8159207e-008+dweta0p
+ peta0=-2.0304172e-014+dpeta0p                       etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.012118209+du0p       lu0=1.3512765e-009+dlu0p
+ wu0=2.788908e-009+dwu0p   pu0=-1.1660982e-015       ua=2.6075928e-009
+ lua=-4.3975541e-016       wua=-1.0861998e-015       pua=1.2810478e-021
+ ub=-1.5190313e-018        lub=1.8610149e-024        wub=3.8376866e-024
+ pub=-2.713493e-030        uc=-1.2195413e-010        luc=1.2403976e-016
+ wuc=1.4269519e-016        puc=-2.1162632e-022       vsat=88037.344
+ lvsat=0.019455389+dlvsatp wvsat=0.028477307+dwvsatp pvsat=-4.2403394e-008+dpvsatp
+ a0=0.25681324             la0=4.546381e-007         wa0=1.5005589e-006
+ pa0=-7.460294e-013        ags=-0.1823676+dagsp      lags=4.4662646e-007
+ wags=7.8692894e-007       pags=-3.9602414e-013      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.0054443204        lketa=-2.7911469e-008     wketa=-4.513326e-008
+ pketa=1.6743373e-014      dwg=0                     dwb=0
+ pclm=0.52300633           lpclm=-2.3213644e-008+dlpclmp
+ wpclm=-1.6446377e-007+dwpclmp                       ppclm=1.6783415e-013+dppclmp
+ pdiblc1=0                 pdiblc2=0.0017101591      lpdiblc2=3.7626446e-010+dlpdiblc2p
+ wpdiblc2=1.0445982e-009+dwpdiblc2p                  ppdiblc2=-3.3166411e-016+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.19626087
+ lkt1=6.8969848e-09        wkt1=4.2564986e-08        pkt1=-1.1621917e-14
+ kt1l=0                    kt2=-0.045                lkt2=-1e-16
+ wkt2=0                    pkt2=0                    ute=-1.0722609
+ lute=2.88307e-008         wute=1.1636448e-007       pute=-2.3341477e-014
+ ua1=3.2131906e-09         lua1=-2.2335867e-16       wua1=6.4543787e-16
+ pua1=-1.5186622e-22       ub1=-6.8509395e-018       lub1=6.670924e-025
+ wub1=-5.7965464e-025      pub1=-3.6233015e-031      uc1=-1.5773219e-10
+ luc1=8.0686107e-17        wuc1=-3.40738e-18         puc1=1.304781e-23
+ prt=0                     at=169701.45              lat=-0.031587237
+ wat=0.010322854           pat=-2.7892591e-08        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     8: type=p 
+ lmin=1.8e-07              lmax=5e-007-dxlp          wmin=1.23e-006-dxwp
+ wmax=1.003e-005-dxwp      version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.48984522+dvthp    lvth0=2.2283804e-009+dlvthp
+ wvth0=5.7289033e-009+dwvthp                         pvth0=1.083617e-015
+ k1=0.493                  k2=0.052782109+dk2p       lk2=-6.2468224e-010+dlk2p
+ wk2=-7.0033501e-009+dwk2p pk2=1.5121895e-015        k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055000001     lkvth0we=5.8000013e-011   wkvth0we=-9.8999853e-011
+ pkvth0we=4.7999979e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00033001112         lcit=7.0010874e-011+dlcitp
+ wcit=-1.0959707e-009+dwcitp                         pcit=6.4492087e-017+dpcitp
+ voff=-0.12851612+dvoffp   tvoff=0.0035              ptvoff=0
+ wtvoff=0                  ltvoff=0                  lvoff=1.1594343e-009+dlvoffp
+ wvoff=-8.4172398e-009+dwvoffp                       pvoff=2.437201e-015+dpvoffp
+ nfactor=1.0075642         lnfactor=-3.1627557e-009+dlnfactorp
+ wnfactor=-7.6224743e-008  pnfactor=3.1871089e-014   eta0=0.19294197
+ leta0=-3.8678642e-010+dleta0p                       weta0=-3.9723265e-008+dweta0p
+ peta0=3.8976468e-015+dpeta0p                        etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.014489167+du0p       lu0=3.5993136e-010+dlu0p
+ wu0=1.2805757e-009+dwu0p  pu0=-5.354343e-016        ua=1.6733617e-009
+ lua=-4.9134688e-017       wua=2.1696697e-015        pua=-8.0296397e-023
+ ub=2.7179937e-018         lub=8.9429929e-026        wub=-2.818145e-024
+ pub=6.9443354e-032        uc=2.4549014e-010         luc=-2.9596037e-017
+ wuc=-4.7843924e-016       puc=4.8082413e-023        vsat=151703.6
+ lvsat=-0.0071647445+dlvsatp                         wvsat=-0.096817419+dwvsatp
+ pvsat=9.9848373e-009+dpvsatp                        a0=1.3527842
+ la0=-3.6092624e-009       wa0=-3.7067404e-007       pa0=3.6370537e-014
+ ags=1.011927+dagsp        lags=-5.2731998e-008      wags=-2.1150664e-007
+ pags=2.1441744e-014       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.084095749
+ lketa=4.9742669e-009      wketa=-6.6492045e-009     pketa=6.5241995e-016
+ dwg=0                     dwb=0                     pclm=0.47402209
+ lpclm=-2.7323516e-009+dlpclmp                       wpclm=3.2279855e-007+dwpclmp
+ ppclm=-3.589997e-014+dppclmp                        pdiblc1=0
+ pdiblc2=0.002799807       lpdiblc2=-7.9339125e-011+dlpdiblc2p
+ wpdiblc2=3.3127257e-010+dwpdiblc2p                  ppdiblc2=-3.3408401e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.17902754
+ lkt1=-3.086182e-10        wkt1=2.1853748e-08        pkt1=-2.962137e-15
+ kt1l=0                    kt2=-0.044999999          lkt2=-1e-17
+ wkt2=2e-16                pkt2=0                    ute=-1.040348
+ lute=1.5487268e-08        wute=7.7533294e-08        pute=-7.105382e-15
+ ua1=2.775592e-09          lua1=-4.0389983e-17       wua1=-1.7983055e-16
+ pua1=1.9319502e-22        ub1=-5.8043209e-18        lub1=2.2948024e-25
+ wub1=-7.5553843e-25       pub1=-2.8878962e-31       uc1=3.7176799e-11
+ luc1=-8.092371e-19        wuc1=1.6328929e-17        puc1=4.795661e-24
+ prt=0                     at=116869.31              lat=-0.0094970689
+ wat=-0.057982917          pat=6.674192e-10          jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     9: type=p 
+ lmin=1e-005-dxlp          lmax=2e-05                wmin=5.3e-007-dxwp
+ wmax=1.23e-006-dxwp       version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.46311873+dvthp    wvth0=-5.8630536e-009+dwvthp
+ k1=0.493                  k2=0.046955033+dk2p       wk2=2.737846e-009+dwk2p
+ k3=-2.62                  k3b=2.309                 w0=0
+ dvt0=9.8                  dvt1=2                    dvt2=-0.1768
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.7                  minv=-0.536               voffl=-4.64e-009
+ dvtp0=0                   dvtp1=0                   lpe0=5.86e-008
+ lpeb=8e-009               web=-500                  wec=0
+ scref=1e-006              kvth0we=-0.005494152      lkvth0we=0
+ wkvth0we=-9.4160431e-011  pkvth0we=0                k2we=0.0023
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=1.5e-007               ngate=6.7045e+019         ndep=5.8e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00018242858
+ wcit=-1.0526129e-010+dwcitp                         voff=-0.11884174+dvoffp
+ tvoff=0.0036648572        ptvoff=0                  wtvoff=-2.1052257e-10
+ ltvoff=0                  wvoff=-1.0673494e-008+dwvoffp
+ nfactor=1                 eta0=0.189                etab=-0.00168699
+ wetab=-8.2009068e-009     ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.014927519+du0p
+ wu0=-9.6735122e-010+dwu0p ua=2.1980286e-009         wua=-1.7894419e-016
+ ub=1.2778079e-018         wub=-5.6275841e-025       uc=-3.7398743e-011
+ wuc=-3.9409825e-017       vsat=92640                a0=0.86597743
+ wa0=1.9515442e-007        ags=0.38476737+dagsp      wags=-3.4820433e-008
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.038840286         wketa=6.9472449e-009
+ dwg=0                     dwb=0                     pclm=0.55980313
+ wpclm=-8.7861595e-008+dwpclmp                       pdiblc1=0
+ pdiblc2=0.00012993571     wpdiblc2=8.9472093e-011+dwpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.1653154
+ pkt1=0                    lkt1=0                    wkt1=1.47365e-10
+ kt1l=0                    kt2=-0.045164185          pkt2=0
+ lkt2=0                    wkt2=9.4736e-11           ute=-1.0998657
+ wute=-2.3157483e-008      ua1=2.829522e-09          pua1=0
+ lua1=0                    wua1=-5.0546469e-16       ub1=-6.2255057e-018
+ wub1=9.494568e-025        uc1=-1.3602223e-010       wuc1=6.4504116e-017
+ prt=0                     at=120000                 pat=0
+ lat=0                     wat=-4e-09                jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   saref=1.00e-05
+ sbref=1.00e-05            rbsb=50                   ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lvth0=0+dlvthp            lk2=0+dlk2p
+ lcit=0+dlcitp             pcit=0+dpcitp             lvoff=0+dlvoffp
+ pvoff=0+dpvoffp           lnfactor=0+dlnfactorp     lu0=0+dlu0p
+ lvsat=0+dlvsatp           wvsat=0+dwvsatp           pvsat=0+dpvsatp
+ lpclm=0+dlpclmp           ppclm=0+dppclmp           lpdiblc2=0+dlpdiblc2p
+ ppdiblc2=0+dppdiblc2p     leta0=0+dleta0p           weta0=0+dweta0p
+ peta0=0+dpeta0p           fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     10: type=p 
+ lmin=1.2e-006-dxlp        lmax=1e-005-dxlp          wmin=5.3e-007-dxwp
+ wmax=1.23e-006-dxwp       version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.46278043+dvthp    lvth0=-3.3552487e-009+dlvthp
+ wvth0=-5.1608974e-009+dwvthp                        pvth0=-6.9640692e-015
+ k1=0.493                  k2=0.046549495+dk2p       lk2=4.0221758e-009+dlk2p
+ wk2=2.9291e-009+dwk2p     pk2=-1.8968798e-015       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054999999     lkvth0we=5.7999947e-011   wkvth0we=-9.9000065e-011
+ pkvth0we=4.8000079e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00022655438         lcit=-4.3764506e-010+dlcitp
+ wcit=-1.453845e-010+dwcitp                          pcit=3.9794682e-016+dpcitp
+ voff=-0.11772334+dvoffp   tvoff=0.0036648572        ptvoff=0
+ wtvoff=-2.1052256e-10     ltvoff=0                  lvoff=-1.1092421e-008+dlvoffp
+ wvoff=-1.1478633e-008+dwvoffp                       pvoff=7.985466e-015+dpvoffp
+ nfactor=1                 eta0=0.189                etab=0.00011890213
+ letab=-1.7911055e-008     wetab=-9.2429065e-009     petab=1.0334679e-014
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.015067159+du0p       lu0=-1.3849693e-009+dlu0p
+ wu0=-1.2306932e-009+dwu0p pu0=2.6118576e-015        ua=2.2366778e-009
+ lua=-3.8332756e-016       wua=-2.6123689e-016       pua=8.1618891e-022
+ ub=1.2299065e-018         lub=4.7509189e-025        wub=-5.6861239e-025
+ pub=5.806044e-032         uc=-4.7868646e-011        luc=1.0384176e-016
+ wuc=-2.9409784e-017       puc=-9.918161e-023        vsat=91765.362
+ lvsat=0.0086747694+dlvsatp                          wvsat=0.00024073926+dwvsatp
+ pvsat=-2.3876809e-009+dpvsatp                       a0=0.81293492
+ la0=5.2608194e-007        wa0=2.1466768e-007        pa0=-1.935348e-013
+ ags=0.36180321+dagsp      lags=2.2776134e-007       wags=-3.7694593e-008
+ pags=2.8506256e-014       a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.036820149
+ lketa=-2.0035963e-008     wketa=7.7138657e-009      pketa=-7.603437e-015
+ dwg=0                     dwb=0                     pclm=0.5726591
+ lpclm=-1.275071e-007+dlpclmp                        wpclm=-1.0427868e-007+dwpclmp
+ ppclm=1.6282657e-013+dppclmp                        pdiblc1=0
+ pdiblc2=-0.00019470709    lpdiblc2=3.2198463e-009+dlpdiblc2p
+ wpdiblc2=1.093732e-010+dwpdiblc2p                   ppdiblc2=-1.9738162e-016+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.16621651
+ lkt1=8.937388e-09         wkt1=1.249413e-09         pkt1=-1.093027e-14
+ kt1l=0                    kt2=-0.045190284          lkt2=2.588422e-10
+ wkt2=1.134591e-10         pkt2=-1.857081e-16        ute=-1.1461354
+ lute=4.5890817e-007       wute=1.2191064e-008       pute=-3.5059113e-013
+ ua1=2.5739994e-09         lua1=2.5343035e-15        wua1=-3.3797705e-16
+ pua1=-1.6611627e-21       ub1=-5.9918994e-018       lub1=-2.3169354e-024
+ wub1=8.9127814e-025       pub1=5.7702287e-031       uc1=-1.4012949e-10
+ luc1=4.073622e-17         wuc1=6.8709028e-17        puc1=-4.1704819e-23
+ prt=0                     at=118383.8               lat=0.016029748
+ wat=0.00044135            pat=-4.37741e-09          jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     11: type=p 
+ lmin=5e-007-dxlp          lmax=1.2e-006-dxlp        wmin=5.3e-007-dxwp
+ wmax=1.23e-006-dxwp       version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.46431722+dvthp    lvth0=-1.6369375e-009+dlvthp
+ wvth0=-1.0741668e-008+dwvthp                        pvth0=-7.2409777e-016
+ k1=0.493                  k2=0.052094928+dk2p       lk2=-2.1782845e-009+dlk2p
+ wk2=6.3341977e-010+dwk2p  pk2=6.6996619e-016        k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055           lkvth0we=5.8000032e-011   wkvth0we=-9.8999949e-011
+ pkvth0we=4.7999949e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00026308099         lcit=-4.7848619e-010+dlcitp
+ wcit=-1.5288955e-010+dwcitp                         pcit=4.0633836e-016+dpcitp
+ voff=-0.13306828+dvoffp   tvoff=0.0036648571        ptvoff=0
+ wtvoff=-2.1052257e-10     ltvoff=0                  lvoff=6.065062e-009+dlvoffp
+ wvoff=9.5856942e-011+dwvoffp                        pvoff=-4.9562032e-015+dpvoffp
+ nfactor=1                 eta0=0.21165428           leta0=-2.5330203e-008+dleta0p
+ weta0=-1.3071519e-008+dweta0p                       peta0=1.4615527e-014+dpeta0p
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.013242673+du0p
+ lu0=6.5502497e-010+dlu0p  wu0=1.3529673e-009+dwu0p  pu0=-2.7698497e-016
+ ua=1.1103413e-009         lua=8.7605175e-016        wua=8.2579035e-016
+ pua=-3.9923799e-022       ub=2.2473151e-018         lub=-6.6249308e-025
+ wub=-9.7193782e-025       pub=5.0902668e-031        uc=1.0291619e-010
+ luc=-6.4753787e-017       wuc=-1.4446421e-016       puc=2.9463046e-023
+ vsat=116536.53            lvsat=-0.019022369+dlvsatp
+ wvsat=-0.0079161528+dwvsatp                         pvsat=6.7327033e-009+dpvsatp
+ a0=1.4753889              la0=-2.1462115e-007       wa0=-5.556223e-008
+ pa0=1.0861467e-013        ags=0.41986894+dagsp      lags=1.6283688e-007
+ wags=1.7872885e-008       pags=-3.3624851e-014      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.042199189         lketa=-1.402155e-008      wketa=1.8027073e-009
+ pketa=-9.9405267e-016     dwg=0                     dwb=0
+ pclm=0.32811765           lpclm=1.4591959e-007+dlpclmp
+ wpclm=8.4409083e-008+dwpclmp                        ppclm=-4.8148987e-014+dppclmp
+ pdiblc1=0                 pdiblc2=0.0025703201      lpdiblc2=1.2821407e-010+dlpdiblc2p
+ wpdiblc2=-5.3827398e-011+dwpdiblc2p                 ppdiblc2=-1.490376e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.1485369
+ lkt1=-1.083054e-08        wkt1=-1.8378527e-08       pkt1=1.1016129e-14
+ kt1l=0                    kt2=-0.044934168          lkt2=-2.75256e-11
+ wkt2=-8.4068e-11          pkt2=3.51504e-17          ute=-0.36258271
+ lute=-4.1719775e-007      wute=-7.8989456e-007      pute=5.4623685e-013
+ ua1=8.4614964e-09         lua1=-4.0486246e-15       wua1=-6.0566487e-15
+ pua1=4.7329984e-21        ub1=-1.1065167e-017       lub1=3.3555871e-024
+ wub1=4.8019145e-024       pub1=-3.7955379e-030      uc1=-2.6685161e-10
+ luc1=1.8242678e-16        wuc1=1.3593812e-16        puc1=-1.1687502e-22
+ prt=0                     at=172282.91              lat=-0.044235923
+ wat=0.007026342           pat=-1.1740218e-08        jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     12: type=p 
+ lmin=1.8e-07              lmax=5e-007-dxlp          wmin=5.3e-007-dxwp
+ wmax=1.23e-006-dxwp       version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.47709758+dvthp    lvth0=3.7067884e-009+dlvthp
+ wvth0=-1.0549828e-008+dwvthp                        pvth0=-8.0430993e-016
+ k1=0.493                  k2=0.044959723+dk2p       lk2=8.0508781e-010+dlk2p
+ wk2=2.9858379e-009+dwk2p  pk2=-3.1362689e-016       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054999999     lkvth0we=5.7999984e-011   wkvth0we=-9.9000108e-011
+ pkvth0we=4.8000016e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.001416708          lcit=2.2386717e-010+dlcitp
+ wcit=1.1345896e-009+dwcitp                          pcit=-1.319824e-016+dpcitp
+ voff=-0.12335005+dvoffp-0.0037911991                tvoff=0.0037154065
+ ptvoff=2.6990267e-17      wtvoff=-2.7507406e-10     ltvoff=-2.1135683e-11
+ lvoff=2.0016755e-009+dlvoffp+1.5851762e-09          wvoff=-1.5014308e-008+dwvoffp+4.8413613e-09
+ pvoff=1.3616589e-015+dpvoffp-2.02427e-15            nfactor=0.90490683
+ lnfactor=3.9760358e-008+dlnfactorp                  wnfactor=5.4868761e-008
+ pnfactor=-2.2941726e-014  eta0=0.13308213           leta0=7.5223835e-009+dleta0p
+ weta0=3.6717752e-008+dweta0p                        peta0=-6.2023632e-015+dpeta0p
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.015670806+du0p
+ lu0=-3.6022584e-010+dlu0p wu0=-2.2837633e-010+dwu0p pu0=3.8420644e-016
+ ua=3.9336567e-009         lua=-3.0443287e-016       wua=-7.1672704e-016
+ pua=2.4571938e-022        ub=1.323592e-019          lub=2.2181229e-025
+ wub=4.8371032e-025        pub=-9.9608927e-032       uc=-1.158162e-010
+ luc=2.6702601e-017        wuc=-1.7051042e-017       puc=-2.3810948e-023
+ vsat=70977.126            lvsat=2.6928398e-005+dlvsatp
+ wvsat=0.0062702822+dwvsatp                          pvsat=8.010711e-010+dpvsatp
+ a0=0.92737249             la0=1.4515488e-008        wa0=1.7257667e-007
+ pa0=1.322523e-014         ags=0.84053845+dagsp      lags=-1.3053452e-008
+ wags=7.3565455e-009       pags=-2.9227759e-014      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.088714584         lketa=5.427467e-009       wketa=-7.5095217e-010
+ pketa=7.3683427e-017      dwg=0                     dwb=0
+ pclm=0.7535018            lpclm=-3.1942034e-008+dlpclmp
+ wpclm=-3.4097044e-008+dwpclmp                       ppclm=1.4007948e-015+dppclmp
+ pdiblc1=0                 pdiblc2=0.0032170396      lpdiblc2=-1.421923e-010+dlpdiblc2p
+ wpdiblc2=-2.0153347e-010+dwpdiblc2p                 ppdiblc2=4.6855102e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.16310921
+ lkt1=-4.7375652e-09       wkt1=1.526044e-09         pkt1=2.6936288e-15
+ kt1l=0                    kt2=-0.044999999          lkt2=1e-16
+ wkt2=-7e-16               pkt2=-1e-22               ute=-1.5461709
+ lute=7.7684143e-008       wute=7.2346917e-007       pute=-8.6530791e-014
+ ua1=-3.423962e-09         lua1=9.2092325e-16        wua1=7.7370002e-15
+ pua1=-1.034402e-21        ub1=-1.293409e-018        lub1=-7.3018056e-025
+ wub1=-6.5159729e-024      pub1=9.3669722e-031       uc1=3.0275982e-10
+ luc1=-5.5739159e-17       wuc1=-3.2282058e-16       puc1=7.4941174e-23
+ prt=0                     at=86685.717              lat=-0.0084460284
+ wat=-0.019438456          pat=-6.747578e-10         jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  fnoimod=1                 noia=noiap
+ noib=noibp                noic=noicp                em=3.00e7
+ ef=1.104                  minr=1e-3
 
 
 
     13: type=p 
+ lmin=1e-005-dxlp          lmax=2e-05                wmin=2.2e-07
+ wmax=5.3e-007-dxwp        version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.47328+dvthp       k1=0.493
+ k2=0.061901123+dk2p       wk2=-5.8860477e-009+dwk2p k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054941522     lkvth0we=0                wkvth0we=-9.4160364e-011
+ pkvth0we=0                k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-1.0651293e-011       wcit=2.5462971e-018+dwcitp
+ voff=-0.13842523+dvoffp   tvoff=0.0031277419        ptvoff=0
+ wtvoff=9.939291e-11       ltvoff=0                  wvoff=6.2617529e-010+dwvoffp
+ nfactor=1                 eta0=0.189                etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.013251+du0p          ua=1.7655106e-009
+ wua=7.0618658e-017        ub=3.5625174e-019         wub=-3.1020525e-026
+ uc=-1.057e-010            vsat=92640                a0=1.1079077
+ wa0=5.5560633e-008        ags=0.21935981+dagsp      wags=6.0619732e-008
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.042649809         wketa=9.1453398e-009
+ dwg=0                     dwb=0                     pclm=0.4667351
+ wpclm=-3.4161341e-008+dwpclmp                       pdiblc1=0
+ pdiblc2=0.00027208065     wpdiblc2=7.4544677e-012+dwpdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.18139007
+ pkt1=0                    wkt1=9.422447e-09         lkt1=0
+ kt1l=0                    kt2=-0.045000001          pkt2=0
+ wkt2=0                    lkt2=0                    ute=-1.14
+ ua1=1.8221532e-09         pua1=0                    wua1=7.5787084e-17
+ lua1=0                    ub1=-4.58e-018            uc1=-6.023194e-11
+ puc1=0                    luc1=0                    wuc1=2.0773118e-17
+ prt=0                     at=119999.99              pat=0
+ lat=0                     wat=1e-09                 jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=1.00e-05            sbref=1.00e-05
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lvth0=0+dlvthp            wvth0=0+dwvthp
+ lk2=0+dlk2p               lcit=0+dlcitp             pcit=0+dpcitp
+ lvoff=0+dlvoffp           pvoff=0+dpvoffp           lnfactor=0+dlnfactorp
+ lu0=0+dlu0p               wu0=0+dwu0p               lvsat=0+dlvsatp
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           lpclm=0+dlpclmp
+ ppclm=0+dppclmp           lpdiblc2=0+dlpdiblc2p     ppdiblc2=0+dppdiblc2p
+ leta0=0+dleta0p           weta0=0+dweta0p           peta0=0+dpeta0p
+ fnoimod=1                 noia=noiap                noib=noibp
+ noic=noicp                em=3.00e7                 ef=1.104
+ minr=1e-3
 
 
 
     14: type=p 
+ lmin=1.2e-006-dxlp        lmax=1e-005-dxlp          wmin=2.2e-07
+ wmax=5.3e-007-dxwp        version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.47105506+dvthp    lvth0=-2.2067262e-008+dlvthp
+ wvth0=-3.8644042e-010+dwvthp                        pvth0=3.8327625e-015
+ k1=0.493                  k2=0.062202518+dk2p       lk2=-2.9892741e-009+dlk2p
+ wk2=-6.1026943e-009+dwk2p pk2=2.1487268e-015        k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055000001     lkvth0we=5.8000146e-011   wkvth0we=-9.8999987e-011
+ pkvth0we=4.7999964e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-4.7298785e-005       lcit=4.6911492e-010+dlcitp
+ wcit=1.2628776e-011+dwcitp                          pcit=-1.2525369e-016+dpcitp
+ voff=-0.1381244+dvoffp    lvoff=-2.9836357e-009+dlvoffp
+ tvoff=0.003127742         ptvoff=0                  wtvoff=9.939291e-11
+ ltvoff=0                  wvoff=2.9277571e-010+dwvoffp
+ pvoff=3.306697e-015+dpvoffp                         nfactor=1
+ eta0=0.189                etab=-0.0159              ku0we=0
+ lku0we=0                  wku0we=0                  pku0we=0
+ u0=0.012761991+du0p       lu0=4.8500463e-009+dlu0p  wu0=9.9388435e-011+dwu0p
+ pu0=-9.8574643e-016       ua=1.7151175e-009         lua=4.9980573e-016
+ wua=3.9703424e-017        pua=3.06621e-022          ub=8.0525916e-020
+ lub=2.7346818e-024        wub=9.4580189e-026        pub=-1.245723e-030
+ uc=-1.1180683e-010        luc=6.0568261e-017        wuc=7.4825474e-018
+ puc=-7.4212803e-023       vsat=91788.622            lvsat=0.008444068+dlvsatp
+ wvsat=0.00022731789+dwvsatp                         pvsat=-2.2545662e-009+dpvsatp
+ a0=1.0721262              la0=3.5488541e-007        wa0=6.5114299e-008
+ pa0=-9.4754405e-014       ags=0.16739788+dagsp      lags=5.1536466e-007
+ wags=7.4477283e-008       pags=-1.3744086e-013      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.037358179         lketa=-5.2483026e-008     wketa=8.024309e-009
+ pketa=1.1118518e-014      dwg=0                     dwb=0
+ pclm=0.46510904           lpclm=1.6127471e-008+dlpclmp
+ wpclm=-4.2222286e-008+dwpclmp                       ppclm=7.9949421e-014+dppclmp
+ pdiblc1=0                 pdiblc2=-9.1744484e-006   lpdiblc2=2.7895218e-009+dlpdiblc2p
+ wpdiblc2=2.320872e-012+dwpdiblc2p                   ppdiblc2=5.0915619e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.1798406
+ lkt1=-1.53677e-08         wkt1=9.1105158e-09        pkt1=3.093766e-15
+ kt1l=0                    kt2=-0.044988174          lkt2=-1.17279e-10
+ wkt2=-3.15724e-12         pkt2=3.13141e-17          ute=-1.0845709
+ lute=-5.4975265e-007      wute=-2.3331656e-008      pute=2.3140617e-013
+ ua1=2.0839263e-09         lua1=-2.5962969e-15       wua1=-5.5204844e-17
+ pua1=1.2991938e-21        ub1=-4.5776695e-018       lub1=-2.3114274e-026
+ wub1=7.5267481e-026       pub1=-7.4651191e-031      uc1=-7.0013104e-11
+ luc1=9.7010758e-17        wuc1=2.8251877e-17        puc1=-7.4175225e-23
+ prt=0                     at=118415.48              lat=0.015715337
+ wat=0.0004230648          pat=-4.195997e-09         jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     15: type=p 
+ lmin=5e-007-dxlp          lmax=1.2e-006-dxlp        wmin=2.2e-07
+ wmax=5.3e-007-dxwp        version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.49135323+dvthp    lvth0=6.2852941e-010+dlvthp
+ wvth0=4.8581081e-009+dwvthp                         pvth0=-2.0312722e-015
+ k1=0.493                  k2=0.060186145+dk2p       lk2=-7.3472705e-010+dlk2p
+ wk2=-4.0352121e-009+dwk2p pk2=-1.6296644e-016       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0054999998     lkvth0we=5.7999904e-011   wkvth0we=-9.900004e-011
+ pkvth0we=4.8000024e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00014052712         lcit=2.5910302e-010+dlcitp
+ wcit=-8.2175962e-011+dwcitp                         pcit=-1.9250614e-017+dpcitp
+ voff=-0.14099926+dvoffp   tvoff=0.0029734036        ptvoff=-9.9572166e-17
+ wtvoff=1.884461e-10       ltvoff=1.7256874e-10      lvoff=2.3080262e-010+dlvoffp
+ wvoff=4.6720307e-009+dwvoffp                        pvoff=-1.5898356e-015+dpvoffp
+ nfactor=1                 eta0=0.189                etab=-0.0159
+ ku0we=0                   lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.016605688+du0p       lu0=5.5233201e-010+dlu0p
+ wu0=-5.8749248e-010+dwu0p pu0=-2.1773114e-016       ua=2.072246e-009
+ lua=1.0049318e-016        wua=2.7077137e-016        pua=4.825931e-023
+ ub=1.6993676e-018         lub=9.2462252e-025        wub=-6.5577213e-025
+ pub=-4.0673902e-031       uc=-1.0676735e-010        luc=5.4933522e-017
+ wuc=-2.3476805e-017       puc=-3.9596531e-023       vsat=104264.2
+ lvsat=-0.0055051196+dlvsatp                         wvsat=-0.00083501563+dwvsatp
+ pvsat=-1.0667498e-009+dpvsatp                       a0=1.480818
+ la0=-1.0208098e-007       wa0=-5.8694769e-008       pa0=4.367899e-014
+ ags=0.38698297+dagsp      lags=2.6984217e-007       wags=3.6848087e-008
+ pags=-9.5366901e-014      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.06312954
+ lketa=-2.3667551e-008     wketa=1.387952e-008       pketa=4.57169e-015
+ dwg=0                     dwb=0                     pclm=0.50323683
+ lpclm=-2.6503974e-008+dlpclmp                       wpclm=-1.6634681e-008+dwpclmp
+ ppclm=5.1339409e-014+dppclmp                        pdiblc1=0
+ pdiblc2=0.0023486111      lpdiblc2=1.5323458e-010+dlpdiblc2p
+ wpdiblc2=7.4098693e-011+dwpdiblc2p                  ppdiblc2=-2.9340598e-017+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.20965257
+ lkt1=1.796566e-08         wkt1=1.6885211e-08        pkt1=-5.599276e-15
+ kt1l=0                    kt2=-0.045148654          lkt2=6.21558e-11
+ wkt2=3.9691e-11           pkt2=-1.65954e-17         ute=-2.5510369
+ lute=1.0899324e-006       wute=4.7284353e-007       pute=-3.2337723e-013
+ ua1=-8.1714545e-09        lua1=8.8704494e-15        wua1=3.5405641e-15
+ pua1=-2.7213074e-21       ub1=1.8185611e-018        lub1=-7.1748676e-024
+ wub1=-2.6319968e-024      pub1=2.2805345e-030       uc1=1.8658524e-10
+ luc1=-1.8989697e-16       wuc1=-1.2569493e-16       puc1=9.7955778e-23
+ prt=0                     at=178758.42              lat=-0.051755308
+ wat=0.003289966           pat=-7.401537e-09         jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     leta0=0+dleta0p
+ weta0=0+dweta0p           peta0=0+dpeta0p           fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     16: type=p 
+ lmin=1.8e-07              lmax=5e-007-dxlp          wmin=2.2e-07
+ wmax=5.3e-007-dxwp        version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=toxp
+ toxm=toxp                 dtox=6.556e-010           epsrox=3.9
+ wint=-2.35e-008           lint=3.344e-008           ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+dxlp          xw=0+dxwp                 dlc=3.344e-008+dlcp
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.49241047+dvthp    lvth0=1.0705825e-009+dlvthp
+ wvth0=-1.7142946e-009+dwvthp                        pvth0=7.1678087e-016
+ k1=0.493                  k2=0.056440429+dk2p       lk2=8.314315e-010+dlk2p
+ wk2=-3.6385299e-009+dwk2p pk2=-3.2882721e-016       k3=-2.62
+ k3b=2.309                 w0=0                      dvt0=9.8
+ dvt1=2                    dvt2=-0.1768              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.7
+ minv=-0.536               voffl=-4.64e-009          dvtp0=0
+ dvtp1=0                   lpe0=5.86e-008            lpeb=8e-009
+ web=-500                  wec=0                     scref=1e-006
+ kvth0we=-0.0055000001     lkvth0we=5.8000025e-011   wkvth0we=-9.8999965e-011
+ pkvth0we=4.7999992e-017   k2we=0.0023               lk2we=0
+ wk2we=0                   pk2we=0                   xj=1.5e-007
+ ngate=6.7045e+019         ndep=5.8e+017             nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00081359137         lcit=-2.2318605e-011+dlcitp
+ wcit=-1.5229316e-010+dwcitp                         pcit=1.0066789e-017+dpcitp
+ voff=-0.15167884+dvoffp+0.0085607722                tvoff=0.0033512133
+ ptvoff=6.371386e-18       wtvoff=-6.4934632e-11     ltvoff=1.4598951e-11
+ lvoff=4.6961502e-009+dlvoffp-3.5794301e-09          wvoff=1.3314046e-009+dwvoffp-2.2857262e-09
+ pvoff=-1.9305298e-016+dpvoffp+9.5570783e-16         nfactor=1
+ eta0=0.19443335           leta0=-2.2717904e-009+dleta0p
+ weta0=1.3181021e-009+dweta0p                        peta0=-5.5112485e-016+dpeta0p
+ etab=-0.0159              ku0we=0                   lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.016704734+du0p
+ lu0=5.1091887e-010+dlu0p  wu0=-8.2495321e-010+dwu0p pu0=-1.1844406e-016
+ ua=1.8777014e-009         lua=1.8183616e-016        wua=4.6955918e-016
+ pua=-3.485785e-023        ub=3.5667728e-018         lub=1.4382307e-025
+ wub=-1.4979463e-024       pub=-5.4609145e-032       uc=6.1745049e-011
+ luc=-1.5524884e-017       wuc=-1.1950388e-016       puc=5.5431054e-025
+ vsat=84312.007            lvsat=0.0028372891+dlvsatp
+ wvsat=-0.0014239441+dwvsatp                         pvsat=-8.2050703e-010+dpvsatp
+ a0=1.2131375              la0=9.8415509e-009        wa0=7.6902339e-009
+ pa0=1.5922092e-014        ags=1.320679+dagsp        lags=-1.2055482e-007
+ wags=-2.6968456e-007      pags=3.280053e-014        a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.14103023          lketa=8.9042862e-009      wketa=2.9435177e-008
+ pketa=-1.9324412e-015     dwg=0                     dwb=0
+ pclm=0.43394723           lpclm=2.4673915e-009+dlpclmp
+ wpclm=1.5028595e-007+dwpclmp                        ppclm=-1.8453444e-014+dppclmp
+ pdiblc1=0                 pdiblc2=0.0028285795      lpdiblc2=-4.7449802e-011+dlpdiblc2p
+ wpdiblc2=2.2608022e-011+dwpdiblc2p                  ppdiblc2=-7.8113186e-018+dppdiblc2p
+ pdiblcb=0                 drout=0.5                 pvag=1.26
+ delta=0.005               pscbe1=4.773e+008         pscbe2=1e-020
+ fprout=0                  pdits=0.01699             pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=200
+ rsw=369                   rdw=369                   prwg=0
+ prwb=0                    wr=1                      alpha0=1.223e-007
+ alpha1=0.0143             beta0=19.27               agidl=0
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5.064
+ noff=1.773                voffcv=-0.06538           kt1=-0.17209166
+ lkt1=2.2606857e-09        wkt1=6.7089159e-09        pkt1=-1.3443624e-15
+ kt1l=0                    kt2=-0.045                lkt2=8e-17
+ wkt2=5e-16                pkt2=9.9999998e-24        ute=0.43954123
+ lute=-1.6048817e-07       wute=-4.2228673e-07       pute=5.0894633e-14
+ ua1=1.7026317e-08         lua1=-1.6652429e-15       wua1=-4.0628112e-15
+ pua1=4.578159e-22         ub1=-1.9106345e-17        lub1=1.5742541e-24
+ wub1=3.7620911e-24        pub1=-3.9296157e-31       uc1=-5.2872513e-10
+ luc1=1.0918861e-16        wuc1=1.5694624e-16        puc1=-2.0222142e-23
+ prt=0                     at=97517.211              lat=-0.017786729
+ wat=-0.025688225          pat=4.714825e-09          jss=1.76e-07
+ jsd=1.76e-07              jsws=2.71e-13             jswd=2.71e-13
+ jswgs=1e-12               jswgd=1e-12               njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10.2
+ bvd=10.2                  xjbvs=1                   xjbvd=1
+ pbs=0.86                  pbd=0.86                  cjs=cjp
+ cjd=cjp                   mjs=0.44                  mjd=0.44
+ pbsws=0.6                 pbswd=0.6                 cjsws=cjswp
+ cjswd=cjswp               mjsws=0.338               mjswd=0.338
+ pbswgs=0.95               pbswgd=0.95               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.45765            mjswgd=0.45765
+ tpb=0.00161               tcj=0.000918              tpbsw=0.00125
+ tcjsw=0.000886            tpbswg=0.00115            tcjswg=0.000723
+ xtis=3                    xtid=3                    jtsswgs=6.5702e-011
+ jtsswgd=6.5702e-011       njtsswg=7.1               xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=0                vtsswgs=10
+ vtsswgd=10                dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             rshg=8.41
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=1.00e-05            sbref=1.00e-05            ngcon=1
+ wlod=5e-006               kvth0=-2.3e-009           lkvth0=1e-008
+ wkvth0=2.5e-007           pkvth0=4e-014             llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=5.54e-008             lku0=5e-008
+ wku0=1e-008               pku0=1e-014               llodku0=1
+ wlodku0=1                 kvsat=-0.6                steta0=0
+ tku0=0.5                  lnfactor=0+dlnfactorp     fnoimod=1
+ noia=noiap                noib=noibp                noic=noicp
+ em=3.00e7                 ef=1.104                  minr=1e-3
 
 
 
     } 
endsection mos
 
 
// *********************************************************************************************

section mos_5
// *********************************************************************************************
//                                                                            
//                   *
//                                     5V NMOS DEVICE MODELS                  
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
// *********************************
//        Macro   model            *
// *********************************
 
inline subckt nch_5_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2e-007 dmci=2e-007 
+ xw=1e-08 + dxwn_5 ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf 
+ * dmcg + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor 
+ + (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 
+ 1) * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.000000e-05 / factor sb=1.000000e-05 
+ / factor sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor 
+ mismatchflag=mismatchflag_mos_5 lef=(l) * factor wef=(w / nf) * factor temp1=par1n_5 
+ temp2=par2n_5 temp3=par3n_5 temp4=par4n_5 temp5=par5n_5 mis_a_1=0.01 mis_a_2=-0.32 
+ mis_a_3=0 mis_b_1=0.0013 mis_b_2=0.5 mis_b_3=-0.17 mis_c_1=1 mis_c_2=0 mis_c_3=0 
+ mis_d_1=5.26e-03 mis_d_2=0 mis_d_3=0 mis_e_1=0.0095 mis_e_2=-1.05 mis_e_3=0.1 
+ e_limit=2 mis_f_1=2e-03 mis_f_2=0 mis_f_3=0 a=mis_a_1 * pow(lef * 1e6,mis_a_2) 
+ * pow(wef * 1e6,mis_a_3) b=mis_b_1 * pow(lef * 1e6,mis_b_2) * pow(wef * 1e6,mis_b_3) 
+ c=mis_c_1 * pow(lef * 1e6,mis_c_2) * pow(wef * 1e6,mis_c_3) d=mis_d_1 * pow(lef 
+ * 1e6,mis_d_2) * pow(wef * 1e6,mis_d_3) e=mis_e_1 * pow(lef * 1e6,mis_e_2) * pow(wef 
+ * 1e6,mis_e_3) f=mis_f_1 * pow(lef * 1e6,mis_f_2) * pow(wef * 1e6,mis_f_3) fac1=temp1 
+ fac2=temp2 fac3=temp3 fac4=temp4 fac5=c * temp4 + sqrt(1 - c * c) * temp5 geo_fac=1 
+ / sqrt(multi * nf * lef * wef * 1e12) * mismatchflag * sigma toxmisn_5=d * geo_fac 
+ * toxn_5 * fac1 dxlmisn_5=b * geo_fac * lef * fac2 dxwmisn_5= - b * geo_fac * 
+ wef * fac3 dvthmisn_5=a * geo_fac * fac4 fu0misn_5=min(e_limit,1 + e * geo_fac 
+ * fac5) dk2misn_5=f * geo_fac * fac5 
nch_5_mac ( n1 n2 n3 n4 ) nch_5 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
 
 
 
 
 
 
model nch_5 bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_5-dxlmisn_5                        lmax=900.01e-06
+ wmin=1e-005-dxwn_5-dxwmisn_5                        wmax=900.01e-06
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.80837352+dvthn_5+dvthmisn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       k1=0.9                    k2=0.0079679065+dk2n_5+dk2misn_5
+ k3=-2.6117                k3b=1.11                  w0=0
+ dvt0=6.88                 dvt1=0.2902               dvt2=0.005
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56                 minv=-0.2968              voffl=0
+ dvtp0=1e-007              dvtp1=1                   lpe0=1.2252e-007
+ lpeb=2.246e-008           xj=1.5e-007               ngate=8e+019
+ ndep=2.4905e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0004              cdscd=0
+ cit=0.00053254            voff=-0.1221858           nfactor=0.5
+ eta0=0.2882+deta0n_5      etab=-0.47086             ud=0
+ lud=0                     wud=0                     pud=0
+ u0=(0.054978+du0n_5)*fu0misn_5                      ua=4.8644942e-010
+ ub=2.07977e-018           ku0=-4.500000e-08         tku0=0.000000e+00
+ pku0=1.300000e-13         wku0=1.500000e-07         lku0=-1.400000e-07
+ uc=9.333e-011             vsat=98936                a0=1.8732798
+ kvsat=-5.000000e-02       ags=0.1950454+dagsn_5     a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.01917             dwg=0                     dwb=0
+ pclm=0.099988             pdiblc1=0                 pdiblc2=0.00035793185+dpdiblc2n_5
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.02                pscbe1=3.9e+008           pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=651.4
+ prwg=0                    prwb=0                    wr=1
+ alpha0=4e-008             alpha1=22.782             beta0=41.34+dbeta0n_5
+ agidl=1.6674e-013         bgidl=1.2e+009            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00180344          ltvoff=0                  wtvoff=0
+ ptvoff=0                  kt1=-0.3795984            kt1l=0
+ kt2=-0.069439             ute=-1.2445               ua1=3.3789114e-009
+ ub1=-3.3042e-018          uc1=5.9040106e-011        prt=0
+ at=120000                 fnoimod=1                 tnoimod=0
+ em=1.192e+007             ef=0.9                    noia=3.6e+41
+ noib=1.0e+023             noic=1e+006               lintnoi=1e-008
+ jss=2.72e-07              jsd=2.72e-07              jsws=1.32e-13
+ jswd=1.32e-13             jswgs=1.33e-13            jswgd=1.33e-13
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   jtsswgs=1e-009            jtsswgd=1e-009
+ njtsswg=30                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.726                 pbd=0.726                 cjs=cjn_5
+ cjd=cjn_5                 mjs=0.322                 mjd=0.322
+ pbsws=0.406               pbswd=0.406               cjsws=cjswn_5
+ cjswd=cjswn_5             mjsws=0.118               mjswd=0.118
+ pbswgs=0.659              pbswgd=0.659              cjswgs=cjswgn_5
+ cjswgd=cjswgn_5           mjswgs=0.307              mjswgd=0.307
+ tpb=0.00171               tcj=0.00099               tpbsw=0.0023
+ tcjsw=0.00125             tpbswg=0.00203            tcjswg=0.00122
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthn_5          wvth0=0+dwvthn_5
+ pvth0=0+dpvthn_5          lu0=(0+dlu0n_5)*fu0misn_5 wu0=(0+dwu0n_5)*fu0misn_5
+ pu0=(0+dpu0n_5)*fu0misn_5 lvsat=0+dlvsatn_5         pvsat=0+dpvsatn_5
+ lk2=0+dlk2n_5             wk2=0+dwk2n_5             pk2=0+dpk2n_5
+ pbeta0=0+dpbeta0n_5       lpdiblc2=0+dlpdiblc2n_5   wpdiblc2=0+dwpdiblc2n_5
+ ppdiblc2=0+dppdiblc2n_5   wags=0+dwagsn_5           weta0=0+dweta0n_5
+ ppclm=0+dppclmn_5         la0=0+dla0n_5             lua1=0+dlua1n_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=0.000000e+00         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=-6.000000e-09        lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        web=0.000000e+00          wec=0.000000e+00
+ kvth0we=1.250000e-02      pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09
+ lkvth0we=7.000000e-09     ku0we=-5.000000e-03       pku0we=0.000000e+00
+ wku0we=2.500000e-09       lku0we=0.000000e+00       k2we=4.000000e-07
+ pk2we=0.000000e+00        lk2we=1.000000e-09        wk2we=1.500000e-09
+ rshg=8.23                 minr=1e-3
 
     2: type=n 
+ lmin=1.2e-006-dxln_5-dxlmisn_5                      lmax=1e-005-dxln_5-dxlmisn_5
+ wmin=1e-005-dxwn_5-dxwmisn_5                        wmax=900.01e-06
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.80760233+dvthn_5+dvthmisn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=7.5715486e-009+dlvthn_5
+ k1=0.9                    k2=0.007762618+dk2n_5+dk2misn_5
+ lk2=2.0155225e-009+dlk2n_5                          k3=-2.6117
+ k3b=1.11                  w0=0                      dvt0=6.88
+ dvt1=0.2902               dvt2=0.005                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.2968              voffl=0                   dvtp0=1e-007
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=2.246e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0004              cdscd=0                   cit=0.00053630429
+ lcit=-3.6957764e-011      voff=-0.12353949          lvoff=1.3290484e-008
+ nfactor=0.5               eta0=0.2882+deta0n_5      etab=-0.47086
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=(0.054769541+du0n_5)*fu0misn_5
+ ku0=-4.500000e-08         tku0=0.000000e+00         pku0=1.300000e-13
+ wku0=1.500000e-07         lku0=-1.400000e-07        lu0=(2.0466469e-009+dlu0n_5)*fu0misn_5
+ ua=5.2564879e-010         lua=-3.8485946e-016       ub=2.0440967e-018
+ lub=3.5024012e-025        uc=9.0244766e-011         luc=3.0290828e-017
+ vsat=100435.49            lvsat=-0.014722001+dlvsatn_5
+ kvsat=-5.000000e-02       a0=1.9093884              la0=-3.5451456e-007+dla0n_5
+ ags=0.19148171+dagsn_5    lags=3.4988349e-008       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.018382091         lketa=-7.7356892e-009     dwg=0
+ dwb=0                     pclm=0.08841843           lpclm=1.1359004e-007
+ pdiblc1=0                 pdiblc2=0.00031141988+dpdiblc2n_5
+ lpdiblc2=4.5665457e-010+dlpdiblc2n_5                pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=20.764278          lalpha1=1.9809997e-005    beta0=41.16185+dbeta0n_5
+ lbeta0=1.7490767e-006     agidl=1.2873158e-013      lagidl=3.7316665e-019
+ bgidl=1.1884318e+009      lbgidl=113.57641          cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00171909          ltvoff=8.28154e-010       wtvoff=0
+ ptvoff=0                  kt1=-0.38168383           lkt1=2.0474771e-008
+ kt1l=0                    kt2=-0.070591307          lkt2=1.1313346e-008
+ ute=-1.2466054            lute=2.0670906e-008       ua1=3.41564e-009
+ lua1=-3.6060135e-016+dlua1n_5                       ub1=-3.4474372e-018
+ lub1=1.4063031e-024       uc1=4.6083755e-011        luc1=1.2720546e-016
+ prt=0                     at=133551.58              lat=-0.13304942
+ fnoimod=1                 tnoimod=0                 em=1.192e+007
+ ef=0.9                    noia=3.6e+41              noib=1.0e+023
+ noic=1e+006               lintnoi=1e-008            jss=2.72e-07
+ jsd=2.72e-07              jsws=1.32e-13             jswd=1.32e-13
+ jswgs=1.33e-13            jswgd=1.33e-13            njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ jtsswgs=1e-009            jtsswgd=1e-009            njtsswg=30
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.726
+ pbd=0.726                 cjs=cjn_5                 cjd=cjn_5
+ mjs=0.322                 mjd=0.322                 pbsws=0.406
+ pbswd=0.406               cjsws=cjswn_5             cjswd=cjswn_5
+ mjsws=0.118               mjswd=0.118               pbswgs=0.659
+ pbswgd=0.659              cjswgs=cjswgn_5           cjswgd=cjswgn_5
+ mjswgs=0.307              mjswgd=0.307              tpb=0.00171
+ tcj=0.00099               tpbsw=0.0023              tcjsw=0.00125
+ tpbswg=0.00203            tcjswg=0.00122            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthn_5          pvth0=0+dpvthn_5          wu0=(0+dwu0n_5)*fu0misn_5
+ pu0=(0+dpu0n_5)*fu0misn_5 pvsat=0+dpvsatn_5         wk2=0+dwk2n_5
+ pk2=0+dpk2n_5             pbeta0=0+dpbeta0n_5       wpdiblc2=0+dwpdiblc2n_5
+ ppdiblc2=0+dppdiblc2n_5   wags=0+dwagsn_5           weta0=0+dweta0n_5
+ ppclm=0+dppclmn_5         saref=1.000000e-05        sbref=1.000000e-05
+ llodvth=1.000000e+00      wlodvth=1.000000e+00      wlod=0.000000e+00
+ steta0=0.000000e+00       lodeta0=1.000000e+00      stk2=-6.000000e-09
+ lodk2=1.000000e+00        llodku0=1.000000e+00      wlodku0=1.000000e+00
+ wpemod=1.000000e+00       scref=1.000000e-06        web=0.000000e+00
+ wec=0.000000e+00          kvth0we=1.250000e-02      pkvth0we=0.000000e+00
+ wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09     ku0we=-5.000000e-03
+ pku0we=0.000000e+00       wku0we=2.500000e-09       lku0we=0.000000e+00
+ k2we=4.000000e-07         pk2we=0.000000e+00        lk2we=1.000000e-09
+ wk2we=1.500000e-09        rshg=8.23                 minr=1e-3
 
     3: type=n 
+ lmin=6e-07                lmax=1.2e-006-dxln_5-dxlmisn_5
+ wmin=1e-005-dxwn_5-dxwmisn_5                        wmax=900.01e-06
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.76738559+dvthn_5+dvthmisn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=4.851219e-008+dlvthn_5
+ k1=0.9                    k2=0.011304779+dk2n_5+dk2misn_5
+ lk2=-1.5903978e-009+dlk2n_5                         k3=-2.6117
+ k3b=1.11                  w0=0                      dvt0=6.88
+ dvt1=0.2902               dvt2=0.005                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.2968              voffl=0                   dvtp0=1e-007
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=2.246e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0004              cdscd=0                   cit=0.00044905973
+ lcit=5.1857191e-011       voff=-0.093139132         lvoff=-1.7657076e-008
+ nfactor=0.5               eta0=0.17547933+deta0n_5  leta0=1.1474964e-007
+ etab=-0.47086             ud=0                      lud=0
+ wud=0                     pud=0                     u0=(0.050851367+du0n_5)*fu0misn_5
+ ku0=-4.500000e-08         tku0=0.000000e+00         pku0=1.300000e-13
+ wku0=1.500000e-07         lku0=-1.400000e-07        lu0=(6.0353487e-009+dlu0n_5)*fu0misn_5
+ ua=-5.8285628e-010        lua=7.4359871e-016        ub=3.9505538e-018
+ lub=-1.5905331e-024       uc=2.0638667e-010         luc=-8.7941627e-017
+ vsat=91179.413            lvsat=-0.0052993135+dlvsatn_5
+ kvsat=-5.000000e-02       a0=3.2748054              la0=-1.744509e-006+dla0n_5
+ ags=0.091151875+dagsn_5   lags=1.3712412e-007       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.03502443          lketa=9.2062117e-009      dwg=0
+ dwb=0                     pclm=0.21928846           lpclm=-1.9635656e-008
+ pdiblc1=0                 pdiblc2=-0.00018189333+dpdiblc2n_5
+ lpdiblc2=9.5884741e-010+dlpdiblc2n_5                pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=51.490493          lalpha1=-1.146929e-005    beta0=46.279733+dbeta0n_5
+ lbeta0=-3.4609285e-006    agidl=3.2654643e-013      lagidl=1.7179113e-019
+ bgidl=1.3139333e+009      lbgidl=-14.184133         cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00324983          ltvoff=-7.30142e-010      wtvoff=0
+ ptvoff=0                  kt1=-0.3800122            lkt1=1.8773048e-008
+ kt1l=0                    kt2=-0.062264667          lkt2=2.8368267e-009
+ ute=-1.1871473            lute=-3.9857415e-008      ua1=2.5451959e-009
+ lua1=5.2551072e-016+dlua1n_5                        ub1=-2.0862033e-018
+ lub1=2.0566993e-026       uc1=1.151325e-010         luc1=5.6913835e-017
+ prt=0                     at=-9978.9464             lat=0.013064652
+ fnoimod=1                 tnoimod=0                 em=1.192e+007
+ ef=0.9                    noia=3.6e+41              noib=1.0e+023
+ noic=1e+006               lintnoi=1e-008            jss=2.72e-07
+ jsd=2.72e-07              jsws=1.32e-13             jswd=1.32e-13
+ jswgs=1.33e-13            jswgd=1.33e-13            njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ jtsswgs=1e-009            jtsswgd=1e-009            njtsswg=30
+ xtsswgs=0.61              xtsswgd=0.61              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 pbs=0.726
+ pbd=0.726                 cjs=cjn_5                 cjd=cjn_5
+ mjs=0.322                 mjd=0.322                 pbsws=0.406
+ pbswd=0.406               cjsws=cjswn_5             cjswd=cjswn_5
+ mjsws=0.118               mjswd=0.118               pbswgs=0.659
+ pbswgd=0.659              cjswgs=cjswgn_5           cjswgd=cjswgn_5
+ mjswgs=0.307              mjswgd=0.307              tpb=0.00171
+ tcj=0.00099               tpbsw=0.0023              tcjsw=0.00125
+ tpbswg=0.00203            tcjswg=0.00122            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthn_5          pvth0=0+dpvthn_5          wu0=(0+dwu0n_5)*fu0misn_5
+ pu0=(0+dpu0n_5)*fu0misn_5 pvsat=0+dpvsatn_5         wk2=0+dwk2n_5
+ pk2=0+dpk2n_5             pbeta0=0+dpbeta0n_5       wpdiblc2=0+dwpdiblc2n_5
+ ppdiblc2=0+dppdiblc2n_5   wags=0+dwagsn_5           weta0=0+dweta0n_5
+ ppclm=0+dppclmn_5         saref=1.000000e-05        sbref=1.000000e-05
+ llodvth=1.000000e+00      wlodvth=1.000000e+00      wlod=0.000000e+00
+ steta0=0.000000e+00       lodeta0=1.000000e+00      stk2=-6.000000e-09
+ lodk2=1.000000e+00        llodku0=1.000000e+00      wlodku0=1.000000e+00
+ wpemod=1.000000e+00       scref=1.000000e-06        web=0.000000e+00
+ wec=0.000000e+00          kvth0we=1.250000e-02      pkvth0we=0.000000e+00
+ wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09     ku0we=-5.000000e-03
+ pku0we=0.000000e+00       wku0we=2.500000e-09       lku0we=0.000000e+00
+ k2we=4.000000e-07         pk2we=0.000000e+00        lk2we=1.000000e-09
+ wk2we=1.500000e-09        rshg=8.23                 minr=1e-3
 
     4: type=n 
+ lmin=1e-005-dxln_5-dxlmisn_5                        lmax=900.01e-06
+ wmin=1.2e-006-dxwn_5-dxwmisn_5                      wmax=1e-005-dxwn_5-dxwmisn_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.80505613+dvthn_5+dvthmisn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       wvth0=3.3207084e-008+dwvthn_5
+ k1=0.9                    k2=0.0064475561+dk2n_5+dk2misn_5
+ wk2=1.5218707e-008+dwk2n_5                          k3=-2.6117
+ k3b=1.11                  w0=0                      dvt0=6.88
+ dvt1=0.2902               dvt2=0.005                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.2968              voffl=0                   dvtp0=1e-007
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=2.246e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0004              cdscd=0                   cit=0.00053494488
+ wcit=-2.4072799e-011      voff=-0.12342822          wvoff=1.2436649e-008
+ nfactor=0.5               eta0=0.23509063+deta0n_5  weta0=5.3162484e-007+dweta0n_5
+ etab=-0.46980675          wetab=-1.0543032e-008     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=(0.056349975+du0n_5)*fu0misn_5                   ku0=-4.500000e-08
+ tku0=0.000000e+00         pku0=1.300000e-13         wku0=1.500000e-07
+ lku0=-1.400000e-07        wu0=(-1.373347e-008+dwu0n_5)*fu0misn_5
+ ua=5.4690809e-010         wua=-6.0519129e-016       ub=2.0893221e-018
+ wub=-9.5616771e-026       uc=9.6948587e-011         wuc=-3.6222061e-017
+ vsat=98936                a0=1.8835895              wa0=-1.0320032e-007
+ kvsat=-5.000000e-02       ags=0.19639914+dagsn_5    wags=-1.3550962e-008+dwagsn_5
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.018756262         wketa=-4.1415124e-009
+ dwg=0                     dwb=0                     pclm=0.07442785
+ wpclm=2.558571e-007       pdiblc1=0                 pdiblc2=0.00037430423+dpdiblc2n_5
+ wpdiblc2=-1.6388752e-010+dwpdiblc2n_5               pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=24.409588          walpha1=-1.6292151e-005   beta0=41.838575+dbeta0n_5
+ wbeta0=-4.9907358e-006    agidl=1.5423987e-013      wagidl=1.2512625e-019
+ bgidl=1.233e+009          wbgidl=-330.33            cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00161981          ltvoff=0                  wtvoff=1.83809e-009
+ ptvoff=0                  kt1=-0.38041261           wkt1=8.1502321e-009
+ kt1l=0                    kt2=-0.069805025          wkt2=3.6639103e-009
+ ute=-1.2527088            wute=8.2169588e-008       ua1=3.4530108e-009
+ wua1=-7.4173537e-016      ub1=-3.365265e-018        wub1=6.112608e-025
+ uc1=5.9888908e-011        wuc1=-8.4965088e-018      prt=0
+ at=120000                 fnoimod=1                 tnoimod=0
+ em=1.192e+007             ef=0.9                    noia=3.6e+41
+ noib=1.0e+023             noic=1e+006               lintnoi=1e-008
+ jss=2.72e-07              jsd=2.72e-07              jsws=1.32e-13
+ jswd=1.32e-13             jswgs=1.33e-13            jswgd=1.33e-13
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   jtsswgs=1e-009            jtsswgd=1e-009
+ njtsswg=30                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.726                 pbd=0.726                 cjs=cjn_5
+ cjd=cjn_5                 mjs=0.322                 mjd=0.322
+ pbsws=0.406               pbswd=0.406               cjsws=cjswn_5
+ cjswd=cjswn_5             mjsws=0.118               mjswd=0.118
+ pbswgs=0.659              pbswgd=0.659              cjswgs=cjswgn_5
+ cjswgd=cjswgn_5           mjswgs=0.307              mjswgd=0.307
+ tpb=0.00171               tcj=0.00099               tpbsw=0.0023
+ tcjsw=0.00125             tpbswg=0.00203            tcjswg=0.00122
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthn_5          pvth0=0+dpvthn_5
+ lu0=(0+dlu0n_5)*fu0misn_5 pu0=(0+dpu0n_5)*fu0misn_5 lvsat=0+dlvsatn_5
+ pvsat=0+dpvsatn_5         lk2=0+dlk2n_5             pk2=0+dpk2n_5
+ pbeta0=0+dpbeta0n_5       lpdiblc2=0+dlpdiblc2n_5   ppdiblc2=0+dppdiblc2n_5
+ ppclm=0+dppclmn_5         la0=0+dla0n_5             lua1=0+dlua1n_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=0.000000e+00         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=-6.000000e-09        lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        web=0.000000e+00          wec=0.000000e+00
+ kvth0we=1.250000e-02      pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09
+ lkvth0we=7.000000e-09     ku0we=-5.000000e-03       pku0we=0.000000e+00
+ wku0we=2.500000e-09       lku0we=0.000000e+00       k2we=4.000000e-07
+ pk2we=0.000000e+00        lk2we=1.000000e-09        wk2we=1.500000e-09
+ rshg=8.23                 minr=1e-3
 
     5: type=n 
+ lmin=1.2e-006-dxln_5-dxlmisn_5                      lmax=1e-005-dxln_5-dxlmisn_5
+ wmin=1.2e-006-dxwn_5-dxwmisn_5                      wmax=1e-005-dxwn_5-dxwmisn_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.8041019+dvthn_5+dvthmisn_5
+ lvth0=9.3686546e-009+dlvthn_5                       kvth0=7.000000e-09
+ pkvth0=0.000000e+00       wkvth0=1.000000e-08       lkvth0=3.800000e-07
+ wvth0=3.5039334e-008+dwvthn_5                       pvth0=-1.7989031e-014+dpvthn_5
+ k1=0.9                    k2=0.0062028859+dk2n_5+dk2misn_5
+ lk2=2.4021723e-009+dlk2n_5                          wk2=1.5612918e-008+dwk2n_5
+ pk2=-3.8703647e-015+dpk2n_5                         k3=-2.6117
+ k3b=1.11                  w0=0                      dvt0=6.88
+ dvt1=0.2902               dvt2=0.005                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.2968              voffl=0                   dvtp0=1e-007
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=2.246e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0004              cdscd=0                   cit=0.00053851399
+ lcit=-3.5041587e-011      wcit=-2.211915e-011       pcit=-1.9180922e-017
+ voff=-0.12501652          lvoff=1.5593896e-008      wvoff=1.4785107e-008
+ pvoff=-2.3057156e-014     nfactor=0.5               eta0=0.23509063+deta0n_5
+ weta0=5.3162484e-007+dweta0n_5                      etab=-0.46980675
+ wetab=-1.0543032e-008     ud=0                      lud=0
+ wud=0                     pud=0                     u0=(0.056192385+du0n_5)*fu0misn_5
+ ku0=-4.500000e-08         tku0=0.000000e+00         pku0=1.300000e-13
+ wku0=1.500000e-07         lku0=-1.400000e-07        lu0=(1.547223e-009+dlu0n_5)*fu0misn_5
+ wu0=(-1.424266e-008+dwu0n_5)*fu0misn_5              pu0=(4.9992329e-015+dpu0n_5)*fu0misn_5
+ ua=5.9642819e-010         lua=-4.8618832e-016       wua=-7.0850173e-016
+ pua=1.0143019e-021        ub=2.0399949e-018         lub=4.8429435e-025
+ wub=4.1059018e-026        pub=-1.3418829e-030       uc=9.3655284e-011
+ luc=3.2333656e-017        wuc=-3.4139284e-017       puc=-2.0448707e-023
+ vsat=100497.02            lvsat=-0.015326133+dlvsatn_5
+ kvsat=-5.000000e-02       wvsat=-0.00061594607      pvsat=6.0473585e-009+dpvsatn_5
+ a0=1.9153848              la0=-3.1216609e-007+dla0n_5
+ wa0=-6.0023686e-008       pa0=-4.2390822e-013       ags=0.19263976+dagsn_5
+ lags=3.6909577e-008       wags=-1.1592163e-008+dwagsn_5
+ pags=-1.9231492e-014      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.018135528
+ lketa=-6.0943681e-009     wketa=-2.4680937e-009     pketa=-1.6429624e-014
+ dwg=0                     dwb=0                     pclm=0.060003235
+ lpclm=1.4162087e-007      wpclm=2.844361e-007       ppclm=-2.8058859e-013+dppclmn_5
+ pdiblc1=0                 pdiblc2=0.00033083149+dpdiblc2n_5
+ lpdiblc2=4.2681534e-010+dlpdiblc2n_5                wpdiblc2=-1.9431028e-010+dwpdiblc2n_5
+ ppdiblc2=2.9869064e-016+dppdiblc2n_5                pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=22.159284          lalpha1=2.2093479e-005    walpha1=-1.3964013e-005
+ palpha1=-2.2857656e-011   beta0=41.640208+dbeta0n_5 lbeta0=1.9475657e-006
+ wbeta0=-4.7883651e-006    pbeta0=-1.9868746e-012+dpbeta0n_5
+ agidl=1.2092412e-013      lagidl=3.270941e-019      wagidl=7.8152706e-020
+ pagidl=4.6118627e-025     bgidl=1.2217499e+009      lbgidl=110.45306
+ wbgidl=-333.51443         pbgidl=3.1264746e-005     cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.0015127           ltvoff=1.05165e-009       wtvoff=2.06597e-009
+ ptvoff=-2.23724e-015      kt1=-0.38265993           lkt1=2.2064156e-008
+ wkt1=9.7706984e-009       pkt1=-1.5909738e-014      kt1l=0
+ kt2=-0.070968084          lkt2=1.1418915e-008       wkt2=3.771544e-009
+ pkt2=-1.0567484e-015      ute=-1.2535464            lute=8.2243517e-009
+ wute=6.9479629e-008       pute=1.2459001e-013       ua1=3.4975823e-009
+ lua1=-4.3760281e-016+dlua1n_5                       wua1=-8.2024267e-016
+ pua1=7.7078463e-022       ub1=-3.514681e-018        lub1=1.466966e-024
+ wub1=6.7311003e-025       pub1=-6.0723578e-031      uc1=4.6585903e-011
+ luc1=1.306089e-016        wuc1=-5.026505e-018       puc1=-3.4068497e-023
+ prt=0                     at=133514.13              lat=-0.1326817
+ wat=0.00037491901         pat=-3.6809549e-009       fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
     6: type=n 
+ lmin=6e-07                lmax=1.2e-006-dxln_5-dxlmisn_5
+ wmin=1.2e-006-dxwn_5-dxwmisn_5                      wmax=1e-005-dxwn_5-dxwmisn_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.76722902+dvthn_5+dvthmisn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=4.6905247e-008+dlvthn_5
+ wvth0=1.5673061e-009+dwvthn_5                       pvth0=1.6085493e-014+dpvthn_5
+ k1=0.9                    k2=0.0094853277+dk2n_5+dk2misn_5
+ lk2=-9.3935343e-010+dlk2n_5                         wk2=1.8212711e-008+dwk2n_5
+ pk2=-6.5169541e-015+dpk2n_5                         k3=-2.6117
+ k3b=1.11                  w0=0                      dvt0=6.88
+ dvt1=0.2902               dvt2=0.005                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.2968              voffl=0                   dvtp0=1e-007
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=2.246e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0004              cdscd=0                   cit=0.00045301475
+ lcit=5.1996639e-011       wcit=-3.9589729e-011      pcit=-1.3958721e-018
+ voff=-0.093593713         lvoff=-1.6394521e-008     wvoff=4.5503532e-009
+ pvoff=-1.2638177e-014     nfactor=0.5               eta0=0.10687087+deta0n_5
+ leta0=1.3052771e-007      weta0=6.8677075e-007+dweta0n_5
+ peta0=-1.5793853e-013     etab=-0.4698071           letab=3.510573e-013
+ wetab=-1.0539581e-008     petab=-3.5140836e-018     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=(0.051447388+du0n_5)*fu0misn_5                   ku0=-4.500000e-08
+ tku0=0.000000e+00         pku0=1.300000e-13         wku0=1.500000e-07
+ lku0=-1.400000e-07        lu0=(6.3776296e-009+dlu0n_5)*fu0misn_5
+ wu0=(-5.9661727e-009+dwu0n_5)*fu0misn_5             pu0=(-3.4262315e-015+dpu0n_5)*fu0misn_5
+ ua=-6.2318912e-010        lua=7.553821e-016         wua=4.0373178e-016
+ pua=-1.1795181e-022       ub=4.0205006e-018         lub=-1.5318604e-024
+ wub=-7.0016807e-025       pub=-5.8731373e-031       uc=2.1059672e-010
+ luc=-8.6712731e-017       wuc=-4.2142685e-017       puc=-1.2301245e-023
+ vsat=91172.577            lvsat=-0.0058338463+dlvsatn_5
+ kvsat=-5.000000e-02       wvsat=6.8420349e-005      pvsat=5.3506735e-009+dpvsatn_5
+ a0=3.3349865              la0=-1.7573207e-006+dla0n_5
+ wa0=-6.0241347e-007       pa0=1.2824459e-013        ags=0.10405873+dagsn_5
+ lags=1.2708507e-007       wags=-1.2919759e-007+dwagsn_5
+ pags=1.0049083e-013       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.029858935
+ lketa=5.8400598e-009      wketa=-5.1706605e-008     pketa=3.3695181e-014
+ dwg=0                     dwb=0                     pclm=0.21103124
+ lpclm=-1.2125642e-008     wpclm=8.265481e-008       ppclm=-7.5175238e-014+dppclmn_5
+ pdiblc1=0                 pdiblc2=-0.000209419+dpdiblc2n_5
+ lpdiblc2=9.7679034e-010+dlpdiblc2n_5                wpdiblc2=2.7553192e-010+dwpdiblc2n_5
+ ppdiblc2=-1.7960872e-016+dppdiblc2n_5               pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=56.438381          lalpha1=-1.2802641e-005   walpha1=-4.9528356e-005
+ palpha1=1.3346845e-011    beta0=47.038996+dbeta0n_5 lbeta0=-3.5484003e-006
+ wbeta0=-7.6002189e-006    pbeta0=8.7559249e-013+dpbeta0n_5
+ agidl=2.7602337e-013      lagidl=1.6920306e-019     wagidl=5.0573587e-019
+ pagidl=2.5906605e-026     bgidl=1.3413096e+009      lbgidl=-11.258656
+ wbgidl=-274.03626         pbgidl=-2.928403e-005     cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.0032725           ltvoff=-7.39821e-010      wtvoff=-2.26887e-010
+ ptvoff=9.68813e-017       kt1=-0.37877021           lkt1=1.8104429e-008
+ wkt1=-1.2432261e-008      pkt1=6.6928748e-015       kt1l=0
+ kt2=-0.062051216          lkt2=2.3415433e-009       wkt2=-2.1366433e-009
+ pkt2=4.9577862e-015       ute=-1.2121486            lute=-3.3918695e-008
+ wute=2.5026214e-007       pute=-5.944658e-014       ua1=2.6429158e-009
+ lua1=4.3244768e-016+dlua1n_5                        wua1=-9.7817623e-016
+ pua1=9.3156101e-022       ub1=-2.2553866e-018       lub1=1.8500434e-025
+ wub1=1.6935246e-024       pub1=-1.6460178e-030      uc1=1.1162367e-010
+ luc1=6.4400458e-017       wuc1=3.5123393e-017       puc1=-7.4941093e-023
+ prt=0                     at=-9761.8394             lat=0.013173236
+ wat=-0.0021732415         pat=-1.0869275e-009       fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
     7: type=n 
+ lmin=1e-005-dxln_5-dxlmisn_5                        lmax=900.01e-06
+ wmin=5e-007-dxwn_5-dxwmisn_5                        wmax=1.2e-006-dxwn_5-dxwmisn_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.82669732+dvthn_5+dvthmisn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       wvth0=7.0212404e-009+dwvthn_5
+ k1=0.9                    k2=0.013780546+dk2n_5+dk2misn_5
+ wk2=6.3457892e-009+dwk2n_5                          k3=-2.6117
+ k3b=1.11                  w0=0                      dvt0=6.88
+ dvt1=0.2902               dvt2=0.005                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.2968              voffl=0                   dvtp0=1e-007
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=2.246e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0004              cdscd=0                   cit=0.00051556729
+ wcit=-6.2591571e-013      voff=-0.10123057          wvoff=-1.4422509e-008
+ nfactor=0.5               eta0=0.790526+deta0n_5    weta0=-1.4045196e-007+dweta0n_5
+ etab=-0.50963             wetab=3.76431e-008        ud=0
+ lud=0                     wud=0                     pud=0
+ u0=(0.047485886+du0n_5)*fu0misn_5                   ku0=-4.500000e-08
+ tku0=0.000000e+00         pku0=1.300000e-13         wku0=1.500000e-07
+ lku0=-1.400000e-07        wu0=(-3.0079217e-009+dwu0n_5)*fu0misn_5
+ ua=-3.0857429e-010        wua=4.2994239e-016        ub=2.5882757e-018
+ wub=-6.9935061e-025       uc=8.66939e-011           wuc=-2.3813889e-017
+ vsat=98937.457            wvsat=-1.7631429e-006     a0=1.8199091
+ kvsat=-5.000000e-02       wa0=-2.6147056e-008       ags=0.19077107+dagsn_5
+ wags=-6.7409976e-009+dwagsn_5                       a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.027956571         wketa=6.9908614e-009      dwg=0
+ dwb=0                     pclm=0.42131706           wpclm=-1.6387884e-007
+ pdiblc1=0                 pdiblc2=0.0001991773+dpdiblc2n_5
+ wpdiblc2=4.8016066e-011+dwpdiblc2n_5                pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=12.541227          walpha1=-1.9314348e-006   beta0=38.597757+dbeta0n_5
+ wbeta0=-1.0693461e-006    agidl=5.6311719e-014      wagidl=2.4361932e-019
+ bgidl=9.8185714e+008      wbgidl=-26.447143         cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00379877          ltvoff=0                  wtvoff=-7.98439e-010
+ ptvoff=0                  kt1=-0.38308367           wkt1=1.1382216e-008
+ kt1l=0                    kt2=-0.0728817            wkt2=7.386687e-009
+ ute=-1.19245              wute=9.2565e-009          ua1=3.5079511e-009
+ wua1=-8.0821314e-016      ub1=-3.521117e-018        wub1=7.9984165e-025
+ uc1=7.9021232e-011        wuc1=-3.1646621e-017      prt=0
+ at=120000                 fnoimod=1                 tnoimod=0
+ em=1.192e+007             ef=0.9                    noia=3.6e+41
+ noib=1.0e+023             noic=1e+006               lintnoi=1e-008
+ jss=2.72e-07              jsd=2.72e-07              jsws=1.32e-13
+ jswd=1.32e-13             jswgs=1.33e-13            jswgd=1.33e-13
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   jtsswgs=1e-009            jtsswgd=1e-009
+ njtsswg=30                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.726                 pbd=0.726                 cjs=cjn_5
+ cjd=cjn_5                 mjs=0.322                 mjd=0.322
+ pbsws=0.406               pbswd=0.406               cjsws=cjswn_5
+ cjswd=cjswn_5             mjsws=0.118               mjswd=0.118
+ pbswgs=0.659              pbswgd=0.659              cjswgs=cjswgn_5
+ cjswgd=cjswgn_5           mjswgs=0.307              mjswgd=0.307
+ tpb=0.00171               tcj=0.00099               tpbsw=0.0023
+ tcjsw=0.00125             tpbswg=0.00203            tcjswg=0.00122
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthn_5          pvth0=0+dpvthn_5
+ lu0=(0+dlu0n_5)*fu0misn_5 pu0=(0+dpu0n_5)*fu0misn_5 lvsat=0+dlvsatn_5
+ pvsat=0+dpvsatn_5         lk2=0+dlk2n_5             pk2=0+dpk2n_5
+ pbeta0=0+dpbeta0n_5       lpdiblc2=0+dlpdiblc2n_5   ppdiblc2=0+dppdiblc2n_5
+ ppclm=0+dppclmn_5         la0=0+dla0n_5             lua1=0+dlua1n_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=0.000000e+00         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=-6.000000e-09        lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        web=0.000000e+00          wec=0.000000e+00
+ kvth0we=1.250000e-02      pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09
+ lkvth0we=7.000000e-09     ku0we=-5.000000e-03       pku0we=0.000000e+00
+ wku0we=2.500000e-09       lku0we=0.000000e+00       k2we=4.000000e-07
+ pk2we=0.000000e+00        lk2we=1.000000e-09        wk2we=1.500000e-09
+ rshg=8.23                 minr=1e-3
 
     8: type=n 
+ lmin=1.2e-006-dxln_5-dxlmisn_5                      lmax=1e-005-dxln_5-dxlmisn_5
+ wmin=5e-007-dxwn_5-dxwmisn_5                        wmax=1.2e-006-dxwn_5-dxwmisn_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.82930583+dvthn_5+dvthmisn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=-2.5610351e-008+dlvthn_5
+ wvth0=4.5425721e-009+dwvthn_5                       pvth0=2.4335566e-014+dpvthn_5
+ k1=0.9                    k2=0.013374856+dk2n_5+dk2misn_5
+ lk2=3.9830663e-009+dlk2n_5                          wk2=6.9348344e-009+dwk2n_5
+ pk2=-5.7832464e-015+dpk2n_5                         k3=-2.6117
+ k3b=1.11                  w0=0                      dvt0=6.88
+ dvt1=0.2902               dvt2=0.005                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.2968              voffl=0                   dvtp0=1e-007
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=2.246e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0004              cdscd=0                   cit=0.00050829488
+ lcit=7.1400459e-011       wcit=1.4445972e-011       pcit=-1.479758e-016
+ voff=-0.099771461         lvoff=-1.4325543e-008     wvoff=-1.5761413e-008
+ pvoff=1.3145365e-014      nfactor=0.5               eta0=0.790526+deta0n_5
+ weta0=-1.4045196e-007+dweta0n_5                     etab=-0.50963
+ wetab=3.76431e-008        ud=0                      lud=0
+ wud=0                     pud=0                     u0=(0.046972206+du0n_5)*fu0misn_5
+ ku0=-4.500000e-08         tku0=0.000000e+00         pku0=1.300000e-13
+ wku0=1.500000e-07         lku0=-1.400000e-07        lu0=(5.0433118e-009+dlu0n_5)*fu0misn_5
+ wu0=(-3.0862437e-009+dwu0n_5)*fu0misn_5             pu0=(7.6896551e-016+dpu0n_5)*fu0misn_5
+ ua=-3.459704e-010         lua=3.6715509e-016        wua=4.3180057e-016
+ pua=-1.8243617e-023       ub=2.6425042e-018         lub=-5.3241571e-025
+ wub=-6.8797725e-025       pub=-1.1166372e-031       uc=8.4829239e-011
+ luc=1.8307246e-017        wuc=-2.3459769e-017       puc=-3.4767504e-024
+ vsat=100424.31            lvsat=-0.014597905+dlvsatn_5
+ kvsat=-5.000000e-02       wvsat=-0.00052796019      pvsat=5.1662027e-009+dpvsatn_5
+ a0=1.8609205              la0=-4.0264925e-007+dla0n_5
+ wa0=5.8781618e-009        pa0=-3.1442359e-013       ags=0.18836619+dagsn_5
+ lags=2.3611106e-008       wags=-6.421142e-009+dwagsn_5
+ pags=-3.140343e-015       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.026124068
+ lketa=-1.7991522e-008     wketa=7.1980389e-009      pketa=-2.034068e-015
+ dwg=0                     dwb=0                     pclm=0.43799818
+ lpclm=-1.6377522e-007     wpclm=-1.7293778e-007     ppclm=8.8940673e-014+dppclmn_5
+ pdiblc1=0                 pdiblc2=0.00016356963+dpdiblc2n_5
+ lpdiblc2=3.4959612e-010+dlpdiblc2n_5                wpdiblc2=8.0765774e-012+dwpdiblc2n_5
+ ppdiblc2=3.921259e-016+dppdiblc2n_5                 pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=11.692175          lalpha1=8.3359941e-006    walpha1=-1.2988112e-006
+ palpha1=-6.2110986e-012   beta0=38.208775+dbeta0n_5 lbeta0=3.819023e-006
+ wbeta0=-6.3633148e-007    pbeta0=-4.251338e-012+dpbeta0n_5
+ agidl=1.0869076e-014      lagidl=4.4615587e-019     wagidl=2.1131931e-019
+ pagidl=3.1712152e-025     bgidl=9.671325e+008       lbgidl=144.56654
+ wbgidl=-25.427325         pbgidl=-1.0012572e-005    cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00401116          ltvoff=-2.08525e-009      wtvoff=-9.5717e-010
+ ptvoff=1.55842e-015       kt1=-0.38289911           lkt1=-1.8119734e-009
+ wkt1=1.0060115e-008       pkt1=1.2980378e-014       kt1l=0
+ kt2=-0.073946282          lkt2=1.0452064e-008       wkt2=7.3751631e-009
+ pkt2=1.1314206e-016       ute=-1.2087985            lute=1.6050943e-007
+ wute=1.5334614e-008       pute=-5.9674927e-014      ua1=3.60148e-009
+ lua1=-9.1826621e-016+dlua1n_5                       wua1=-9.4595884e-016
+ pua1=1.3523874e-021       ub1=-3.8804367e-018       lub1=3.5278007e-024
+ wub1=1.1156744e-024       pub1=-3.1008458e-030      uc1=6.5210285e-011
+ luc1=1.3559588e-016       wuc1=-2.7562007e-017      puc1=-4.0102741e-023
+ prt=0                     at=133444.71              lat=-0.13200013
+ wat=0.00045891804         pat=-4.5056573e-009       fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
     9: type=n 
+ lmin=6e-07                lmax=1.2e-006-dxln_5-dxlmisn_5
+ wmin=5e-007-dxwn_5-dxwmisn_5                        wmax=1.2e-006-dxwn_5-dxwmisn_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.74461155+dvthn_5+dvthmisn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=6.0608426e-008+dlvthn_5
+ wvth0=2.8934437e-008+dwvthn_5                       pvth0=-4.9535265e-016+dpvthn_5
+ k1=0.9                    k2=0.02555766+dk2n_5+dk2misn_5
+ lk2=-8.419028e-009+dlk2n_5                          wk2=-1.2348105e-009+dwk2n_5
+ pk2=2.5334521e-015+dpk2n_5                          k3=-2.6117
+ k3b=1.11                  w0=0                      dvt0=6.88
+ dvt1=0.2902               dvt2=0.005                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.2968              voffl=0                   dvtp0=1e-007
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=2.246e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0004              cdscd=0                   cit=0.000684095
+ lcit=-1.0756406e-010      wcit=-3.1919683e-010      pcit=1.9167257e-016
+ voff=-0.081258158         lvoff=-3.3172086e-008     wvoff=-1.0375668e-008
+ pvoff=7.6626764e-015      nfactor=0.5               eta0=0.79052525+deta0n_5
+ leta0=7.6472742e-013      weta0=-1.4045105e-007+dweta0n_5
+ peta0=-9.2532018e-019     etab=-0.50962414          letab=-5.968582e-012
+ wetab=3.763904e-008       petab=4.13268e-018        ud=0
+ lud=0                     wud=0                     pud=0
+ u0=(0.049785028+du0n_5)*fu0misn_5                   ku0=-4.500000e-08
+ tku0=0.000000e+00         pku0=1.300000e-13         wku0=1.500000e-07
+ lku0=-1.400000e-07        lu0=(2.1798581e-009+dlu0n_5)*fu0misn_5
+ wu0=(-3.9547177e-009+dwu0n_5)*fu0misn_5             pu0=(1.653072e-015+dpu0n_5)*fu0misn_5
+ ua=-1.0142233e-009        lua=1.0474365e-015        wua=8.7688311e-016
+ pua=-4.7133765e-022       ub=5.1807977e-018         lub=-3.1163984e-024
+ wub=-2.1041275e-024       pub=1.3299772e-030        uc=2.0330092e-010
+ luc=-1.0229693e-016       wuc=-3.3314763e-017       puc=6.555634e-024
+ vsat=87293.422            lvsat=-0.001230663+dlvsatn_5
+ kvsat=-5.000000e-02       wvsat=0.0047621979        pvsat=-2.1917834e-010+dpvsatn_5
+ a0=3.3839374              la0=-1.9530805e-006+dla0n_5
+ wa0=-6.6164404e-007       pa0=3.6511402e-013        ags=0.026956951+dagsn_5
+ lags=1.8792572e-007       wags=-3.590444e-008+dwagsn_5
+ pags=2.6873655e-014       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.064148324
+ lketa=2.0717171e-008      wketa=-1.0216445e-008     pketa=1.5693877e-014
+ dwg=0                     dwb=0                     pclm=0.39846434
+ lpclm=-1.2352977e-007     wpclm=-1.4413924e-007     ppclm=5.9623756e-014+dppclmn_5
+ pdiblc1=0                 pdiblc2=-0.00030986932+dpdiblc2n_5
+ lpdiblc2=8.3155697e-010+dlpdiblc2n_5                wpdiblc2=3.9707681e-010+dwpdiblc2n_5
+ ppdiblc2=-3.8763413e-018+dppdiblc2n_5               pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=22.269014          lalpha1=-2.4312277e-006   walpha1=-8.1834211e-006
+ palpha1=7.9743417e-013    beta0=45.03507+dbeta0n_5  lbeta0=-3.1301444e-006
+ wbeta0=-5.1754678e-006    pbeta0=3.6950285e-013+dpbeta0n_5
+ agidl=3.4606361e-013      lagidl=1.0492784e-019     wagidl=4.2098718e-019
+ pagidl=1.0367962e-025     bgidl=1.1490519e+009      lbgidl=-40.62741
+ wbgidl=-41.404471         pbgidl=6.2521633e-006     cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00217817          ltvoff=-2.19276e-010      wtvoff=1.09725e-009
+ ptvoff=-5.32978e-016      kt1=-0.43009901           lkt1=4.6237518e-008
+ wkt1=4.9675578e-008       pkt1=-2.7348163e-014      kt1l=0
+ kt2=-0.073614421          lkt2=1.0114229e-008       wkt2=1.1854835e-008
+ pkt2=-4.4471638e-015      ute=-1.0284849            lute=-2.3049809e-008
+ wute=2.8029118e-008       pute=-7.2597932e-014      ua1=8.8484524e-010
+ lua1=1.8472679e-015+dlua1n_5                        wua1=1.1490892e-015
+ pua1=-7.8037152e-022      ub1=2.007084e-018         lub1=-2.4656953e-024
+ wub1=-3.4640649e-024      pub1=1.5613287e-030       uc1=2.2106073e-010
+ luc1=-2.3059874e-017      wuc1=-9.7295454e-017      puc1=3.0885908e-023
+ prt=0                     at=-8122.1241             lat=0.012114908
+ wat=-0.0041572969         pat=1.9364951e-010        fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
     10: type=n 
+ lmin=1e-005-dxln_5-dxlmisn_5                        lmax=900.01e-06
+ wmin=2.2e-07              wmax=5e-007-dxwn_5-dxwmisn_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.85493656+dvthn_5+dvthmisn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       wvth0=-7.3807716e-009+dwvthn_5
+ k1=0.9                    k2=0.02270344+dk2n_5+dk2misn_5
+ wk2=1.7951131e-009+dwk2n_5                          k3=-2.6117
+ k3b=1.11                  w0=0                      dvt0=6.88
+ dvt1=0.2902               dvt2=0.005                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.2968              voffl=0                   dvtp0=1e-007
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=2.246e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0004              cdscd=0                   cit=0.0008322575
+ wcit=-1.6213792e-010      voff=-0.14342582          wvoff=7.0970689e-009
+ nfactor=0.5               eta0=0.66223964+deta0n_5  weta0=-7.5025918e-008+dweta0n_5
+ etab=-0.44027214          wetab=2.2705929e-009      ud=0
+ lud=0                     wud=0                     pud=0
+ u0=(0.044771857+du0n_5)*fu0misn_5                   ku0=-4.500000e-08
+ tku0=0.000000e+00         pku0=1.300000e-13         wku0=1.500000e-07
+ lku0=-1.400000e-07        wu0=(-1.6237671e-009+dwu0n_5)*fu0misn_5
+ ua=1.9882251e-010         wua=1.7117002e-016        ub=1.4961553e-018
+ wub=-1.4236922e-025       uc=7.2857143e-011         wuc=-1.6757143e-017
+ vsat=102183.57            wvsat=-0.0016572814       a0=1.7269313
+ kvsat=-5.000000e-02       wa0=2.1271643e-008        ags=0.1715329+dagsn_5
+ wags=3.0704699e-009+dwagsn_5                        a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.013201339         wketa=-5.3430736e-010     dwg=0
+ dwb=0                     pclm=0.017831643          wpclm=4.1898722e-008
+ pdiblc1=0                 pdiblc2=0.00025327298+dpdiblc2n_5
+ wpdiblc2=2.0427271e-011+dwpdiblc2n_5                pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=-0.63803214        walpha1=4.7899874e-006    beta0=32.623036+dbeta0n_5
+ wbeta0=1.9777618e-006     agidl=2.078457e-013       wagidl=1.6633699e-019
+ bgidl=9.5464286e+008      wbgidl=-12.567857         cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.000434025         ltvoff=0                  wtvoff=9.17579e-010
+ ptvoff=0                  kt1=-0.38494998           wkt1=1.2334032e-008
+ kt1l=0                    kt2=-0.069070821          wkt2=5.4431389e-009
+ ute=-1.1954929            wute=1.0808357e-008       ua1=1.8730734e-009
+ wua1=2.55745e-017         ub1=-1.2119536e-018       wub1=-3.7783168e-025
+ uc1=6.0503534e-011        wuc1=-2.2202595e-017      prt=0
+ at=120000                 fnoimod=1                 tnoimod=0
+ em=1.192e+007             ef=0.9                    noia=3.6e+41
+ noib=1.0e+023             noic=1e+006               lintnoi=1e-008
+ jss=2.72e-07              jsd=2.72e-07              jsws=1.32e-13
+ jswd=1.32e-13             jswgs=1.33e-13            jswgd=1.33e-13
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   jtsswgs=1e-009            jtsswgd=1e-009
+ njtsswg=30                xtsswgs=0.61              xtsswgd=0.61
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ pbs=0.726                 pbd=0.726                 cjs=cjn_5
+ cjd=cjn_5                 mjs=0.322                 mjd=0.322
+ pbsws=0.406               pbswd=0.406               cjsws=cjswn_5
+ cjswd=cjswn_5             mjsws=0.118               mjswd=0.118
+ pbswgs=0.659              pbswgd=0.659              cjswgs=cjswgn_5
+ cjswgd=cjswgn_5           mjswgs=0.307              mjswgd=0.307
+ tpb=0.00171               tcj=0.00099               tpbsw=0.0023
+ tcjsw=0.00125             tpbswg=0.00203            tcjswg=0.00122
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthn_5          pvth0=0+dpvthn_5
+ lu0=(0+dlu0n_5)*fu0misn_5 pu0=(0+dpu0n_5)*fu0misn_5 lvsat=0+dlvsatn_5
+ pvsat=0+dpvsatn_5         lk2=0+dlk2n_5             pk2=0+dpk2n_5
+ pbeta0=0+dpbeta0n_5       lpdiblc2=0+dlpdiblc2n_5   ppdiblc2=0+dppdiblc2n_5
+ ppclm=0+dppclmn_5         la0=0+dla0n_5             lua1=0+dlua1n_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=0.000000e+00         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=-6.000000e-09        lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        web=0.000000e+00          wec=0.000000e+00
+ kvth0we=1.250000e-02      pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09
+ lkvth0we=7.000000e-09     ku0we=-5.000000e-03       pku0we=0.000000e+00
+ wku0we=2.500000e-09       lku0we=0.000000e+00       k2we=4.000000e-07
+ pk2we=0.000000e+00        lk2we=1.000000e-09        wk2we=1.500000e-09
+ rshg=8.23                 minr=1e-3
 
     11: type=n 
+ lmin=1.2e-006-dxln_5-dxlmisn_5                      lmax=1e-005-dxln_5-dxlmisn_5
+ wmin=2.2e-07              wmax=5e-007-dxwn_5-dxwmisn_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.84930892+dvthn_5+dvthmisn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=5.5252147e-008+dlvthn_5
+ wvth0=-5.6590045e-009+dwvthn_5                      pvth0=-1.6904308e-014+dpvthn_5
+ k1=0.9                    k2=0.022517101+dk2n_5+dk2misn_5
+ lk2=1.8294789e-009+dlk2n_5                          wk2=2.2722894e-009+dwk2n_5
+ pk2=-4.6849168e-015+dpk2n_5                         k3=-2.6117
+ k3b=1.11                  w0=0                      dvt0=6.88
+ dvt1=0.2902               dvt2=0.005                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.2968              voffl=0                   dvtp0=1e-007
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=2.246e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0004              cdscd=0                   cit=0.00088386803
+ lcit=-5.0671222e-010      wcit=-1.7709634e-010      pcit=1.4686167e-016
+ voff=-0.14398747          lvoff=5.5142985e-009      wvoff=6.788753e-009
+ pvoff=3.0270462e-015      nfactor=0.5               eta0=0.66223964+deta0n_5
+ weta0=-7.5025918e-008+dweta0n_5                     etab=-0.44027214
+ wetab=2.2705929e-009      ud=0                      lud=0
+ wud=0                     pud=0                     u0=(0.04406669+du0n_5)*fu0misn_5
+ lu0=(6.923334e-009+dlu0n_5)*fu0misn_5               ku0=-4.500000e-08
+ tku0=0.000000e+00         pku0=1.300000e-13         wku0=1.500000e-07
+ lku0=-1.400000e-07        wu0=(-1.6044306e-009+dwu0n_5)*fu0misn_5
+ pu0=(-1.8984581e-016+dpu0n_5)*fu0misn_5             ua=1.1518091e-010
+ lua=8.2119321e-016        wua=1.966134e-016         pua=-2.4980306e-022
+ ub=1.6296063e-018         lub=-1.310222e-024        wub=-1.7139932e-025
+ pub=2.8501746e-031        uc=7.1369726e-011         luc=1.4603463e-017
+ wuc=-1.6595417e-017       puc=-1.5878212e-024       vsat=101846.64
+ lvsat=0.0033080346+dlvsatn_5                        kvsat=-5.000000e-02
+ wvsat=-0.0012533472       pvsat=-3.9658266e-009+dpvsatn_5
+ a0=1.8464214              la0=-1.1731538e-006+dla0n_5
+ wa0=1.3272688e-008        pa0=7.8533739e-014        ags=0.17210017+dagsn_5
+ lags=-5.5694387e-009      wags=1.8745304e-009+dwagsn_5
+ pags=1.1741735e-014       a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.0081260584
+ lketa=-4.9829099e-008     wketa=-1.9809458e-009     pketa=1.4203097e-014
+ dwg=0                     dwb=0                     pclm=0.015861751
+ lpclm=1.9340399e-008      wpclm=4.2351797e-008      ppclm=-4.4482919e-015+dppclmn_5
+ pdiblc1=0                 pdiblc2=9.9360562e-005+dpdiblc2n_5
+ lpdiblc2=1.5111121e-009+dlpdiblc2n_5                wpdiblc2=4.0823201e-011+dwpdiblc2n_5
+ ppdiblc2=-2.0024724e-016+dppdiblc2n_5               pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=-0.98495654        lalpha1=3.4061038e-006    walpha1=5.1665259e-006
+ palpha1=-3.6968546e-012   beta0=32.862741+dbeta0n_5 lbeta0=-2.3534249e-006
+ wbeta0=2.0901461e-006     pbeta0=-1.1033895e-012+dpbeta0n_5
+ agidl=9.6403952e-014      lagidl=1.0941351e-018     wagidl=1.6769652e-019
+ pagidl=-1.3347892e-026    bgidl=9.3716664e+008      lbgidl=171.5815
+ wbgidl=-10.144736         pbgidl=-2.3790201e-005    cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.000236425         ltvoff=1.94004e-009       wtvoff=9.67944e-010
+ ptvoff=-4.94484e-016      kt1=-0.38766554           lkt1=2.6661403e-008
+ wkt1=1.2490993e-008       pkt1=-1.5410436e-015      kt1l=0
+ kt2=-0.070917529          lkt2=1.8130973e-008       wkt2=5.830499e-009
+ pkt2=-3.8031016e-015      ute=-1.2033444            lute=7.7085931e-008
+ wute=1.2553004e-008       pute=-1.7128945e-014      ua1=1.6456291e-009
+ lua1=2.233048e-015+dlua1n_5                         wua1=5.1525088e-017
+ pua1=-2.5478287e-022      ub1=-8.1175127e-019       lub1=-3.9291862e-024
+ wub1=-4.4935516e-025      pub1=7.0221756e-031       uc1=5.7969388e-011
+ luc1=2.488025e-017        wuc1=-2.386915e-017       puc1=1.6362232e-023
+ prt=0                     at=134531.91              lat=-0.14267429
+ wat=-9.5555697e-005       pat=9.3816583e-010        fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
     12: type=n 
+ lmin=6e-07                lmax=1.2e-006-dxln_5-dxlmisn_5
+ wmin=2.2e-07              wmax=5e-007-dxwn_5-dxwmisn_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_5+toxmisn_5     toxm=toxn_5+toxmisn_5
+ dtox=7e-010               epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_5+dxlmisn_5                          xw=1e-08+dxwn_5+dxwmisn_5
+ dlc=7e-008                dwc=0                     xpart=1
+ toxref=3e-009             dlcig=6.25e-009           vth0=0.82128748+dvthn_5+dvthmisn_5
+ kvth0=7.000000e-09        pkvth0=0.000000e+00       wkvth0=1.000000e-08
+ lkvth0=3.800000e-07       lvth0=8.3777975e-008+dlvthn_5
+ wvth0=-1.0170287e-008+dwvthn_5                      pvth0=-1.2311823e-014+dpvthn_5
+ k1=0.9                    k2=0.042151883+dk2n_5+dk2misn_5
+ lk2=-1.8158729e-008+dlk2n_5                         wk2=-9.6978645e-009+dwk2n_5
+ pk2=7.5006999e-015+dpk2n_5                          k3=-2.6117
+ k3b=1.11                  w0=0                      dvt0=6.88
+ dvt1=0.2902               dvt2=0.005                dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.56
+ minv=-0.2968              voffl=0                   dvtp0=1e-007
+ dvtp1=1                   lpe0=1.2252e-007          lpeb=2.246e-008
+ xj=1.5e-007               ngate=8e+019              ndep=2.4905e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0.0004              cdscd=0                   cit=-2.4276794e-005
+ lcit=4.1777921e-010       wcit=4.2072787e-011       pcit=-7.6252495e-017
+ voff=-0.094444408         lvoff=-4.4920541e-008     wvoff=-3.65068e-009
+ pvoff=1.3654389e-014      nfactor=0.5               eta0=0.66224009+deta0n_5
+ leta0=-4.5541199e-013     weta0=-7.502562e-008+dweta0n_5
+ peta0=-3.0304907e-019     etab=-0.4402747           letab=2.6007622e-012
+ wetab=2.2708263e-009      petab=-2.3768555e-019     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=(0.045127397+du0n_5)*fu0misn_5                   ku0=-4.500000e-08
+ tku0=0.000000e+00         pku0=1.300000e-13         wku0=1.500000e-07
+ lku0=-1.400000e-07        lu0=(5.8435337e-009+dlu0n_5)*fu0misn_5
+ wu0=(-1.5793258e-009+dwu0n_5)*fu0misn_5             pu0=(-2.1540253e-016+dpu0n_5)*fu0misn_5
+ ua=1.0390909e-009         lua=-1.1934713e-016       wua=-1.7030711e-016
+ pua=1.2372201e-022        ub=-1.1127047e-019        lub=4.6199064e-025
+ wub=5.9482727e-025        pub=-4.950012e-031        uc=1.7090784e-010
+ luc=-8.6726332e-017       wuc=-1.6794289e-017       puc=-1.3853702e-024
+ vsat=108859.1             lvsat=-0.0038306584+dlvsatn_5
+ kvsat=-5.000000e-02       wvsat=-0.0062362999       pvsat=1.1068193e-009+dpvsatn_5
+ a0=1.9212866              la0=-1.2493666e-006+dla0n_5
+ wa0=8.4307893e-008        pa0=6.2199001e-015        ags=-0.092172064+dagsn_5
+ lags=2.6345969e-007       wags=2.4851357e-008+dwagsn_5
+ pags=-1.1648675e-014      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.11720697
+ lketa=6.1215273e-008      wketa=1.6843467e-008      pketa=-4.9601554e-015
+ dwg=0                     dwb=0                     pclm=0.037620969
+ lpclm=-2.8104847e-009     wpclm=3.9890881e-008      ppclm=-1.9430794e-015+dppclmn_5
+ pdiblc1=0                 pdiblc2=0.00061380085+dpdiblc2n_5
+ lpdiblc2=9.8741187e-010+dlpdiblc2n_5                wpdiblc2=-7.3994973e-011+dwpdiblc2n_5
+ ppdiblc2=-8.3362338e-017+dppdiblc2n_5               pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.02
+ pscbe1=3.9e+008           pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=651.4                prwg=0
+ prwb=0                    wr=1                      alpha0=4e-008
+ alpha1=1.0024029          lalpha1=1.3829719e-006    walpha1=2.6625504e-006
+ palpha1=-1.1478076e-012   beta0=30.535129+dbeta0n_5 lbeta0=1.6083794e-008
+ wbeta0=2.2195017e-006     pbeta0=-1.2350735e-012+dpbeta0n_5
+ agidl=7.8355508e-013      lagidl=3.9461525e-019     wagidl=1.9786653e-019
+ pagidl=-4.4060959e-026    bgidl=1.1507488e+009      lbgidl=-45.845145
+ wbgidl=-42.269893         pbgidl=8.9132081e-006     cgidl=0.5
+ egidl=0.26                aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_5               cgdo=cgon_5
+ cgbo=0                    cgdl=cgln_5               cgsl=cgln_5
+ clc=1e-007                cle=0.6                   cf=cfn_5
+ ckappas=0.6               ckappad=0.6               acde=0.4664
+ moin=7                    noff=2.5                  voffcv=-0.05
+ tvoff=0.00304649          ltvoff=-9.20602e-010      wtvoff=6.54406e-010
+ ptvoff=-1.75302e-016      kt1=-0.36979957           lkt1=8.4738492e-009
+ wkt1=1.8922868e-008       pkt1=-8.0886918e-015      kt1l=0
+ kt2=-0.052638684          lkt2=-4.7689083e-010      wkt2=1.1572092e-009
+ pkt2=9.5430748e-016       ute=-0.93417846           lute=-1.9692495e-007
+ wute=-2.0067165e-008      pute=1.6078388e-014       ua1=4.1009723e-009
+ lua1=-2.6649144e-016+dlua1n_5                       wua1=-4.9113566e-016
+ pua1=2.9764577e-022       ub1=-6.8119874e-018       lub1=2.1790541e-024
+ wub1=1.0336616e-024       pub1=-8.0749345e-031      uc1=2.9719368e-011
+ luc1=5.363877e-017        wuc1=2.8864205e-019       puc1=-8.2303999e-024
+ prt=0                     at=-17406.274             lat=0.011998783
+ wat=0.00057761944         pat=2.5287354e-010        fnoimod=1
+ tnoimod=0                 em=1.192e+007             ef=0.9
+ noia=3.6e+41              noib=1.0e+023             noic=1e+006
+ lintnoi=1e-008            jss=2.72e-07              jsd=2.72e-07
+ jsws=1.32e-13             jswd=1.32e-13             jswgs=1.33e-13
+ jswgd=1.33e-13            njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   jtsswgs=1e-009
+ jtsswgd=1e-009            njtsswg=30                xtsswgs=0.61
+ xtsswgd=0.61              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 pbs=0.726                 pbd=0.726
+ cjs=cjn_5                 cjd=cjn_5                 mjs=0.322
+ mjd=0.322                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_5             cjswd=cjswn_5             mjsws=0.118
+ mjswd=0.118               pbswgs=0.659              pbswgd=0.659
+ cjswgs=cjswgn_5           cjswgd=cjswgn_5           mjswgs=0.307
+ mjswgd=0.307              tpb=0.00171               tcj=0.00099
+ tpbsw=0.0023              tcjsw=0.00125             tpbswg=0.00203
+ tcjswg=0.00122            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=0.000000e+00         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=-6.000000e-09        lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ web=0.000000e+00          wec=0.000000e+00          kvth0we=1.250000e-02
+ pkvth0we=0.000000e+00     wkvth0we=-6.000000e-09    lkvth0we=7.000000e-09
+ ku0we=-5.000000e-03       pku0we=0.000000e+00       wku0we=2.500000e-09
+ lku0we=0.000000e+00       k2we=4.000000e-07         pk2we=0.000000e+00
+ lk2we=1.000000e-09        wk2we=1.500000e-09        rshg=8.23
+ minr=1e-3
 
     } 
ends nch_5_mac
// 
 
// *********************************************************************************************
//                                                                            
//                   *
//                                    5V PMOS DEVICE MODELS                   
//                   *
//                                                                            
//                   *
// *********************************************************************************************
// *********************************
//        Macro   model            *
// *********************************
 
inline subckt pch_5_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2e-007 dmci=2e-007 
+ xw=1e-08 + dxwp_5 ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf 
+ * dmcg + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor 
+ + (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 
+ 1) * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=1.000000e-05 / factor sb=1.000000e-05 
+ / factor sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor 
+ mismatchflag=mismatchflag_mos_5 lef=(l) * factor wef=(w / nf) * factor temp1=par1p_5 
+ temp2=par2p_5 temp3=par3p_5 temp4=par4p_5 temp5=par5p_5 mis_a_1=-0.00562 mis_a_2=-0.14 
+ mis_a_3=0.035 mis_b_1=0.0015 mis_b_2=-0.15 mis_b_3=0.25 mis_c_1=1 mis_c_2=0 mis_c_3=0 
+ mis_d_1=4.97e-03 mis_d_2=0 mis_d_3=0 mis_e_1=0.0044 mis_e_2=-0.16 mis_e_3=0.18 
+ e_limit=2 mis_f_1=1.125e-03 mis_f_2=0 mis_f_3=0 a=mis_a_1 * pow(lef * 1e6,mis_a_2) 
+ * pow(wef * 1e6,mis_a_3) b=mis_b_1 * pow(lef * 1e6,mis_b_2) * pow(wef * 1e6,mis_b_3) 
+ c=mis_c_1 * pow(lef * 1e6,mis_c_2) * pow(wef * 1e6,mis_c_3) d=mis_d_1 * pow(lef 
+ * 1e6,mis_d_2) * pow(wef * 1e6,mis_d_3) e=mis_e_1 * pow(lef * 1e6,mis_e_2) * pow(wef 
+ * 1e6,mis_e_3) f=mis_f_1 * pow(lef * 1e6,mis_f_2) * pow(wef * 1e6,mis_f_3) fac1=temp1 
+ fac2=temp2 fac3=temp3 fac4=temp4 fac5=c * temp4 + sqrt(1 - c * c) * temp5 geo_fac=1 
+ / sqrt(multi * nf * lef * wef * 1e12) * mismatchflag * sigma toxmisp_5=d * geo_fac 
+ * toxp_5 * fac1 dxlmisp_5=b * geo_fac * lef * fac2 dxwmisp_5= - b * geo_fac * 
+ wef * fac3 dvthmisp_5=a * geo_fac * fac4 fu0misp_5=min(e_limit,1 + e * geo_fac 
+ * fac5) dk2misp_5=f * geo_fac * fac5 
pch_5_mac ( n1 n2 n3 n4 ) pch_5 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
 
 
 
 
 
 
model pch_5 bsim4  { 
     1: type=p 
+ lmin=1e-005-dxlp_5-dxlmisp_5                        lmax=900.01e-6
+ wmin=1e-005-dxwp_5-dxwmisp_5                        wmax=900.01e-6
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.68990316+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ k1=0.97                   k2=0.037302147+dk2p_5+dk2misp_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00078879            voff=-0.16297451          nfactor=0.5
+ eta0=0.004                etab=-0.064227            ud=0
+ lud=0                     wud=0                     pud=0
+ u0=(0.015475+du0p_5)*fu0misp_5                      ua=2.34e-009
+ ub=1.3498624e-019         ku0=7.500000e-08          tku0=0.000000e+00
+ pku0=1.000000e-13         wku0=1.000000e-06         lku0=1.000000e-07
+ uc=-6.4e-011              vsat=77087.124            a0=1.2903138
+ kvsat=-2.550000e-01       ags=0.12003137+dagsp_5    a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.008773             dwg=0                     dwb=0
+ pclm=0.2993+dpclmp_5      pdiblc1=0                 pdiblc2=0.00048+dpdiblc2p_5
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=187                beta0=49.325+dbeta0p_5
+ agidl=5.9232e-012         bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.0025448           ltvoff=0                  wtvoff=0
+ ptvoff=0                  kt1=-0.36894              kt1l=0
+ kt2=-0.05209992           ute=-1.2367               ua1=-7.1436e-011
+ ub1=-1.26e-018            uc1=5.6e-011              prt=0
+ at=70000                  fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.13                   noia=1.67e+41
+ noib=1.612e+24            noic=3.5e9                lintnoi=-1e-7
+ jss=1.94e-07              jsd=1.94e-07              jsws=7.03e-14
+ jswd=7.03e-14             jswgs=8.1e-14             jswgd=8.1e-14
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.4                   bvd=8.4                   xjbvs=1
+ xjbvd=1                   jtsswgs=5.2e-010          jtsswgd=5.2e-010
+ njtsswg=30                xtsswgs=0.48              xtsswgd=0.48
+ tnjtsswg=1.5              vtsswgs=19.9              vtsswgd=19.9
+ pbs=0.822                 pbd=0.822                 cjs=cjp_5
+ cjd=cjp_5                 mjs=0.367                 mjd=0.367
+ pbsws=0.767               pbswd=0.767               cjsws=cjswp_5
+ cjswd=cjswp_5             mjsws=0.275               mjswd=0.275
+ pbswgs=0.783              pbswgd=0.783              cjswgs=cjswgp_5
+ cjswgd=cjswgp_5           mjswgs=0.361              mjswgd=0.361
+ tpb=0.00165               tcj=0.000954              tpbsw=0.0016
+ tcjsw=0.0007              tpbswg=0.00187            tcjswg=0.00115
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthp_5          wvth0=0+dwvthp_5
+ pvth0=0+dpvthp_5          lu0=(0+dlu0p_5)*fu0misp_5 wu0=(0+dwu0p_5)*fu0misp_5
+ pu0=(0+dpu0p_5)*fu0misp_5 lk2=0+dlk2p_5             wk2=0+dwk2p_5
+ pk2=0+dpk2p_5             lvsat=0+dlvsatp_5         pvsat=0+dpvsatp_5
+ pbeta0=0+dpbeta0p_5       wpclm=0+dwpclmp_5         wags=0+dwagsp_5
+ la0=0+dla0p_5             pat=0+dpatp_5             saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     2: type=p 
+ lmin=1.2e-006-dxlp_5-dxlmisp_5                      lmax=1e-005-dxlp_5-dxlmisp_5
+ wmin=1e-005-dxwp_5-dxwmisp_5                        wmax=900.01e-6
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.68643677+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-3.4032994e-008+dlvthp_5                      k1=0.97
+ k2=0.037589912+dk2p_5+dk2misp_5                     lk2=-2.825278e-009+dlk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00077087551         lcit=1.7588443e-010       voff=-0.16210857
+ lvoff=-8.5017542e-009     nfactor=0.5               eta0=0.004
+ etab=-0.064227            ud=0                      lud=0
+ wud=0                     pud=0                     u0=(0.015573098+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(-9.6312795e-010+dlu0p_5)*fu0misp_5
+ ua=2.3212415e-009         lua=1.8417087e-016        ub=1.7102818e-019
+ lub=-3.5385976e-025       uc=-6.5388182e-011        luc=1.3629169e-017
+ vsat=77212.885            lvsat=-0.0012347164+dlvsatp_5
+ kvsat=-2.550000e-01       a0=1.335466               la0=-4.433044e-007+dla0p_5
+ ags=0.11779379+dagsp_5    lags=2.1968563e-008       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.010439651          lketa=-1.636318e-008      dwg=0
+ dwb=0                     pclm=0.29921902+dpclmp_5  lpclm=7.9503486e-010
+ pdiblc1=0                 pdiblc2=0.00041408394+dpdiblc2p_5
+ lpdiblc2=6.4716383e-010   pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=203.55233
+ lalpha1=-0.00016251081    beta0=50.162421+dbeta0p_5 lbeta0=-8.2217962e-006
+ agidl=5.4998739e-012      lagidl=4.1562151e-018     bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5
+ cgdo=cgop_5               cgbo=0                    cgdl=cglp_5
+ cgsl=cglp_5               clc=1e-007                cle=0.6
+ cf=cfp_5                  ckappas=0.6               ckappad=0.6
+ acde=1                    moin=25                   noff=2
+ voffcv=-0.02              tvoff=0.00266682          ltvoff=-1.198e-009
+ wtvoff=0                  ptvoff=0                  kt1=-0.36590516
+ lkt1=-2.979609e-008       kt1l=0                    kt2=-0.052530002
+ lkt2=4.2225452e-009       ute=-1.2493324            lute=1.2402544e-007
+ ua1=-2.2264787e-010       lua1=1.4845981e-015       ub1=-9.2882155e-019
+ lub1=-3.25151e-024        uc1=6.5414186e-011        luc1=-9.2428482e-017
+ prt=0                     at=77193.524              lat=-0.070626018
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=1.67e+41             noib=1.612e+24
+ noic=3.5e9                lintnoi=-1e-7             jss=1.94e-07
+ jsd=1.94e-07              jsws=7.03e-14             jswd=7.03e-14
+ jswgs=8.1e-14             jswgd=8.1e-14             njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=8.4
+ bvd=8.4                   xjbvs=1                   xjbvd=1
+ jtsswgs=5.2e-010          jtsswgd=5.2e-010          njtsswg=30
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1.5
+ vtsswgs=19.9              vtsswgd=19.9              pbs=0.822
+ pbd=0.822                 cjs=cjp_5                 cjd=cjp_5
+ mjs=0.367                 mjd=0.367                 pbsws=0.767
+ pbswd=0.767               cjsws=cjswp_5             cjswd=cjswp_5
+ mjsws=0.275               mjswd=0.275               pbswgs=0.783
+ pbswgd=0.783              cjswgs=cjswgp_5           cjswgd=cjswgp_5
+ mjswgs=0.361              mjswgd=0.361              tpb=0.00165
+ tcj=0.000954              tpbsw=0.0016              tcjsw=0.0007
+ tpbswg=0.00187            tcjswg=0.00115            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthp_5          pvth0=0+dpvthp_5          wu0=(0+dwu0p_5)*fu0misp_5
+ pu0=(0+dpu0p_5)*fu0misp_5 wk2=0+dwk2p_5             pk2=0+dpk2p_5
+ pvsat=0+dpvsatp_5         pbeta0=0+dpbeta0p_5       wpclm=0+dwpclmp_5
+ wags=0+dwagsp_5           pat=0+dpatp_5             saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     3: type=p 
+ lmin=6e-007-dxlp_5-dxlmisp_5                        lmax=1.2e-006-dxlp_5-dxlmisp_5
+ wmin=1e-005-dxwp_5-dxwmisp_5                        wmax=900.01e-6
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.72470853+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=4.9276601e-009+dlvthp_5                       k1=0.97
+ k2=0.033163468+dk2p_5+dk2misp_5                     lk2=1.6808418e-009+dlk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00086774817         lcit=7.7268066e-011       voff=-0.16918644
+ lvoff=-1.2964865e-009     nfactor=0.5               eta0=0.004
+ etab=-0.064227            ud=0                      lud=0
+ wud=0                     pud=0                     u0=(0.015123723+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(-5.0566435e-010+dlu0p_5)*fu0misp_5
+ ua=2.4059966e-009         lua=9.7890222e-017        ub=-1.384176e-019
+ lub=-3.8843955e-026       uc=-6.036e-011            luc=8.51048e-018
+ vsat=80180                lvsat=-0.00425524+dlvsatp_5
+ kvsat=-2.550000e-01       a0=1.1308057              la0=-2.3496017e-007+dla0p_5
+ ags=0.1668044+dagsp_5     lags=-2.792424e-008       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.0019224993        lketa=-3.7785113e-009     dwg=0
+ dwb=0                     pclm=0.21089633+dpclmp_5  lpclm=9.0707533e-008
+ pdiblc1=0                 pdiblc2=0.00041161147+dpdiblc2p_5
+ lpdiblc2=6.4968081e-010   pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=63.118617
+ lalpha1=-1.9549282e-005   beta0=45.924633+dbeta0p_5 lbeta0=-3.9077287e-006
+ agidl=8.7080047e-012      lagidl=8.9033805e-019     bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5
+ cgdo=cgop_5               cgbo=0                    cgdl=cglp_5
+ cgsl=cglp_5               clc=1e-007                cle=0.6
+ cf=cfp_5                  ckappas=0.6               ckappad=0.6
+ acde=1                    moin=25                   noff=2
+ voffcv=-0.02              tvoff=0.00107374          ltvoff=4.23756e-010
+ wtvoff=0                  ptvoff=0                  kt1=-0.38455128
+ lkt1=-1.0814332e-008      kt1l=0                    kt2=-0.052616898
+ lkt2=4.311005e-009        ute=-1.0629887            lute=-6.5672537e-008
+ ua1=1.682751e-009         lua1=-4.5509792e-016      ub1=-4.6838886e-018
+ lub1=5.7114826e-025       uc1=-4.30614e-011         luc1=1.7999665e-017
+ prt=0                     at=40489.97               lat=-0.0332618
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=1.67e+41             noib=1.612e+24
+ noic=3.5e9                lintnoi=-1e-7             jss=1.94e-07
+ jsd=1.94e-07              jsws=7.03e-14             jswd=7.03e-14
+ jswgs=8.1e-14             jswgd=8.1e-14             njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=8.4
+ bvd=8.4                   xjbvs=1                   xjbvd=1
+ jtsswgs=5.2e-010          jtsswgd=5.2e-010          njtsswg=30
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1.5
+ vtsswgs=19.9              vtsswgd=19.9              pbs=0.822
+ pbd=0.822                 cjs=cjp_5                 cjd=cjp_5
+ mjs=0.367                 mjd=0.367                 pbsws=0.767
+ pbswd=0.767               cjsws=cjswp_5             cjswd=cjswp_5
+ mjsws=0.275               mjswd=0.275               pbswgs=0.783
+ pbswgd=0.783              cjswgs=cjswgp_5           cjswgd=cjswgp_5
+ mjswgs=0.361              mjswgd=0.361              tpb=0.00165
+ tcj=0.000954              tpbsw=0.0016              tcjsw=0.0007
+ tpbswg=0.00187            tcjswg=0.00115            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthp_5          pvth0=0+dpvthp_5          wu0=(0+dwu0p_5)*fu0misp_5
+ pu0=(0+dpu0p_5)*fu0misp_5 wk2=0+dwk2p_5             pk2=0+dpk2p_5
+ pvsat=0+dpvsatp_5         pbeta0=0+dpbeta0p_5       wpclm=0+dwpclmp_5
+ wags=0+dwagsp_5           pat=0+dpatp_5             saref=1.000000e-05
+ sbref=1.000000e-05        llodvth=1.000000e+00      wlodvth=1.000000e+00
+ wlod=1.700000e-06         steta0=0.000000e+00       lodeta0=1.000000e+00
+ stk2=6.000000e-09         lodk2=1.000000e+00        llodku0=1.000000e+00
+ wlodku0=1.000000e+00      wpemod=1.000000e+00       scref=1.000000e-06
+ wec=0.000000e+00          web=0.000000e+00          kvth0we=-8.500000e-03
+ pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09
+ ku0we=-2.500000e-03       pku0we=0.000000e+00       wku0we=1.000000e-09
+ lku0we=0.000000e+00       k2we=-8.000000e-04        pk2we=0.000000e+00
+ lk2we=0.000000e+00        wk2we=0.000000e+00        rshg=8.41
+ minr=1e-3
 
     4: type=p 
+ lmin=5e-07                lmax=6e-007-dxlp_5-dxlmisp_5
+ wmin=1e-005-dxwp_5-dxwmisp_5                        wmax=900.01e-6
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.68600758+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-1.1249337e-008+dlvthp_5                      k1=0.97
+ k2=0.043825565+dk2p_5+dk2misp_5                     lk2=-2.7759144e-009+dlk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00091191034         lcit=5.8808276e-011       voff=-0.2217071
+ lvoff=2.0657149e-008      nfactor=0.5               eta0=0.004
+ etab=-0.064227            ud=0                      lud=0
+ wud=0                     pud=0                     u0=(0.014076638+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(-6.7982651e-011+dlu0p_5)*fu0misp_5
+ ua=2.2231664e-009         lua=1.7431325e-016        ub=-3.497941e-019
+ lub=4.9511422e-026        uc=-2.092e-011            luc=-7.97544e-018
+ vsat=70000                a0=1.0394028              la0=-1.9675375e-007+dla0p_5
+ kvsat=-2.550000e-01       ags=0.1+dagsp_5           a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.023550348         lketa=5.2619295e-009      dwg=0
+ dwb=0                     pclm=0.357622+dpclmp_5    lpclm=2.9376204e-008
+ pdiblc1=0                 pdiblc2=-0.0086196054+dpdiblc2p_5
+ lpdiblc2=4.4247295e-009   pdiblcb=-0.2              drout=0.56
+ pvag=0                    delta=0.01                pscbe1=4.11e+008
+ pscbe2=1e-006             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.49
+ rdsw=1000                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=36.9246
+ lalpha1=-8.6001828e-006   beta0=45.83298+dbeta0p_5  lbeta0=-3.8694176e-006
+ agidl=-2.392576e-011      lagidl=1.4531252e-017     bgidl=1.0679e+009
+ cgidl=150                 egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_5
+ cgdo=cgop_5               cgbo=0                    cgdl=cglp_5
+ cgsl=cglp_5               clc=1e-007                cle=0.6
+ cf=cfp_5                  ckappas=0.6               ckappad=0.6
+ acde=1                    moin=25                   noff=2
+ voffcv=-0.02              tvoff=0.00352528          ltvoff=-6.00988e-010
+ wtvoff=0                  ptvoff=0                  kt1=-0.34984757
+ lkt1=-2.5320483e-008      kt1l=0                    kt2=-0.037840302
+ lkt2=-1.8656119e-009      ute=-1.192116             lute=-1.1697312e-008
+ ua1=3.24612e-009          lua1=-1.1085862e-015      ub1=-9.1361866e-018
+ lub1=2.4322088e-024       uc1=-2.23872e-010         luc1=9.3578496e-017
+ prt=0                     at=-43429.877             lat=0.0018166956
+ fnoimod=1                 tnoimod=0                 em=1.192e+07
+ ef=1.13                   noia=1.67e+41             noib=1.612e+24
+ noic=3.5e9                lintnoi=-1e-7             jss=1.94e-07
+ jsd=1.94e-07              jsws=7.03e-14             jswd=7.03e-14
+ jswgs=8.1e-14             jswgd=8.1e-14             njs=1.02
+ njd=1.02                  ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=8.4
+ bvd=8.4                   xjbvs=1                   xjbvd=1
+ jtsswgs=5.2e-010          jtsswgd=5.2e-010          njtsswg=30
+ xtsswgs=0.48              xtsswgd=0.48              tnjtsswg=1.5
+ vtsswgs=19.9              vtsswgd=19.9              pbs=0.822
+ pbd=0.822                 cjs=cjp_5                 cjd=cjp_5
+ mjs=0.367                 mjd=0.367                 pbsws=0.767
+ pbswd=0.767               cjsws=cjswp_5             cjswd=cjswp_5
+ mjsws=0.275               mjswd=0.275               pbswgs=0.783
+ pbswgd=0.783              cjswgs=cjswgp_5           cjswgd=cjswgp_5
+ mjswgs=0.361              mjswgd=0.361              tpb=0.00165
+ tcj=0.000954              tpbsw=0.0016              tcjsw=0.0007
+ tpbswg=0.00187            tcjswg=0.00115            xtis=3
+ xtid=3                    dmcg=2e-007               dmci=2e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.3e-008             gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvthp_5          pvth0=0+dpvthp_5          wu0=(0+dwu0p_5)*fu0misp_5
+ pu0=(0+dpu0p_5)*fu0misp_5 wk2=0+dwk2p_5             pk2=0+dpk2p_5
+ lvsat=0+dlvsatp_5         pvsat=0+dpvsatp_5         pbeta0=0+dpbeta0p_5
+ wpclm=0+dwpclmp_5         wags=0+dwagsp_5           pat=0+dpatp_5
+ saref=1.000000e-05        sbref=1.000000e-05        llodvth=1.000000e+00
+ wlodvth=1.000000e+00      wlod=1.700000e-06         steta0=0.000000e+00
+ lodeta0=1.000000e+00      stk2=6.000000e-09         lodk2=1.000000e+00
+ llodku0=1.000000e+00      wlodku0=1.000000e+00      wpemod=1.000000e+00
+ scref=1.000000e-06        wec=0.000000e+00          web=0.000000e+00
+ kvth0we=-8.500000e-03     pkvth0we=0.000000e+00     wkvth0we=-2.000000e-09
+ lkvth0we=1.000000e-09     ku0we=-2.500000e-03       pku0we=0.000000e+00
+ wku0we=1.000000e-09       lku0we=0.000000e+00       k2we=-8.000000e-04
+ pk2we=0.000000e+00        lk2we=0.000000e+00        wk2we=0.000000e+00
+ rshg=8.41                 minr=1e-3
 
     5: type=p 
+ lmin=1e-005-dxlp_5-dxlmisp_5                        lmax=900.01e-6
+ wmin=1.2e-006-dxwp_5-dxwmisp_5                      wmax=1e-005-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.69390934+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ wvth0=4.0101933e-008+dwvthp_5                       k1=0.97
+ k2=0.03741499+dk2p_5+dk2misp_5                      wk2=-1.1295619e-009+dwk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00080519238         wcit=-1.6418777e-010      voff=-0.16292975
+ wvoff=-4.4800043e-010     nfactor=0.5               eta0=0.004
+ etab=-0.065014738         wetab=7.8852524e-009      ud=0
+ lud=0                     wud=0                     pud=0
+ u0=(0.015641513+du0p_5)*fu0misp_5                   ku0=7.500000e-08
+ tku0=0.000000e+00         pku0=1.000000e-13         wku0=1.000000e-06
+ lku0=1.000000e-07         wu0=(-1.6667901e-009+dwu0p_5)*fu0misp_5
+ ua=2.3402613e-009         wua=-2.6151125e-018       ub=2.0185784e-019
+ wub=-6.6938469e-025       uc=-6.0635969e-011        wuc=-3.3673947e-017
+ vsat=77081.88             wvsat=5.2489437e-005      a0=1.301333
+ kvsat=-2.550000e-01       wa0=-1.1030231e-007       ags=0.12212476+dagsp_5
+ wags=-2.0954877e-008+dwagsp_5                       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.0083760375         wketa=3.9735946e-009      dwg=0
+ dwb=0                     pclm=0.2993+dpclmp_5      pdiblc1=0
+ pdiblc2=0.00051064875+dpdiblc2p_5                   wpdiblc2=-3.0679399e-010
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=188.5675           walpha1=-1.5690675e-005
+ beta0=49.327338+dbeta0p_5 wbeta0=-2.3398375e-008    agidl=5.9987837e-012
+ wagidl=-7.5659334e-019    bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00257091          ltvoff=0                  wtvoff=-2.61374e-010
+ ptvoff=0                  kt1=-0.3683995            wkt1=-5.410365e-009
+ kt1l=0                    kt2=-0.050762676          wkt2=-1.338581e-008
+ ute=-1.229825             wute=-6.881875e-008       ua1=-9.366575e-012
+ wua1=-6.2131494e-016      ub1=-1.31775e-018         wub1=5.780775e-025
+ uc1=5.1730757e-011        wuc1=4.2735122e-017       prt=0
+ at=70000                  fnoimod=1                 tnoimod=0
+ em=1.192e+07              ef=1.13                   noia=1.67e+41
+ noib=1.612e+24            noic=3.5e9                lintnoi=-1e-7
+ jss=1.94e-07              jsd=1.94e-07              jsws=7.03e-14
+ jswd=7.03e-14             jswgs=8.1e-14             jswgd=8.1e-14
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.4                   bvd=8.4                   xjbvs=1
+ xjbvd=1                   jtsswgs=5.2e-010          jtsswgd=5.2e-010
+ njtsswg=30                xtsswgs=0.48              xtsswgd=0.48
+ tnjtsswg=1.5              vtsswgs=19.9              vtsswgd=19.9
+ pbs=0.822                 pbd=0.822                 cjs=cjp_5
+ cjd=cjp_5                 mjs=0.367                 mjd=0.367
+ pbsws=0.767               pbswd=0.767               cjsws=cjswp_5
+ cjswd=cjswp_5             mjsws=0.275               mjswd=0.275
+ pbswgs=0.783              pbswgd=0.783              cjswgs=cjswgp_5
+ cjswgd=cjswgp_5           mjswgs=0.361              mjswgd=0.361
+ tpb=0.00165               tcj=0.000954              tpbsw=0.0016
+ tcjsw=0.0007              tpbswg=0.00187            tcjswg=0.00115
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.3e-008
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvthp_5          pvth0=0+dpvthp_5
+ lu0=(0+dlu0p_5)*fu0misp_5 pu0=(0+dpu0p_5)*fu0misp_5 lk2=0+dlk2p_5
+ pk2=0+dpk2p_5             lvsat=0+dlvsatp_5         pvsat=0+dpvsatp_5
+ pbeta0=0+dpbeta0p_5       wpclm=0+dwpclmp_5         la0=0+dla0p_5
+ pat=0+dpatp_5             saref=1.000000e-05        sbref=1.000000e-05
+ llodvth=1.000000e+00      wlodvth=1.000000e+00      wlod=1.700000e-06
+ steta0=0.000000e+00       lodeta0=1.000000e+00      stk2=6.000000e-09
+ lodk2=1.000000e+00        llodku0=1.000000e+00      wlodku0=1.000000e+00
+ wpemod=1.000000e+00       scref=1.000000e-06        wec=0.000000e+00
+ web=0.000000e+00          kvth0we=-8.500000e-03     pkvth0we=0.000000e+00
+ wkvth0we=-2.000000e-09    lkvth0we=1.000000e-09     ku0we=-2.500000e-03
+ pku0we=0.000000e+00       wku0we=1.000000e-09       lku0we=0.000000e+00
+ k2we=-8.000000e-04        pk2we=0.000000e+00        lk2we=0.000000e+00
+ wk2we=0.000000e+00        rshg=8.41                 minr=1e-3
 
     6: type=p 
+ lmin=1.2e-006-dxlp_5-dxlmisp_5                      lmax=1e-005-dxlp_5-dxlmisp_5
+ wmin=1.2e-006-dxwp_5-dxwmisp_5                      wmax=1e-005-dxwp_5-dxwmisp_5
+ version=4.5               binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_5+toxmisp_5     toxm=toxp_5+toxmisp_5
+ dtox=1.5777e-010          epsrox=3.9                wint=0
+ lint=7.6e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3e-08+dxlp_5+dxlmisp_5
+ xw=1e-08+dxwp_5+dxwmisp_5 dlc=6.33e-008             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=6.25e-009
+ vth0=-0.68971121+dvthp_5+dvthmisp_5                 kvth0=1.250000e-07
+ pkvth0=0.000000e+00       wkvth0=4.500000e-05       lkvth0=3.000000e-07
+ lvth0=-4.1217263e-008+dlvthp_5                      wvth0=3.2777168e-008+dwvthp_5
+ pvth0=7.1914534e-014+dpvthp_5                       k1=0.97
+ k2=0.037738795+dk2p_5+dk2misp_5                     lk2=-3.1791121e-009+dlk2p_5
+ wk2=-1.4903156e-009+dwk2p_5                         pk2=3.5418794e-015+dpk2p_5
+ k3=0                      k3b=0                     w0=0
+ dvt0=4.0687               dvt1=0.52816              dvt2=0.054
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.56029329           minv=-0.1944              voffl=0
+ dvtp0=4.3355e-007         dvtp1=0.1                 lpe0=7.3862e-008
+ lpeb=1e-008               xj=1.5e-007               ngate=1.5e+021
+ ndep=1.424026e+017        nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0.0015              cdscd=0
+ cit=0.00078869021         lcit=1.6201831e-010       wcit=-1.7832506e-010
+ pcit=1.3879984e-016       voff=-0.16193509          lvoff=-9.7655842e-009
+ wvoff=-1.7365458e-009     pvoff=1.2650939e-014      nfactor=0.5
+ eta0=0.004                etab=-0.065014738         wetab=7.8852524e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=(0.015746912+du0p_5)*fu0misp_5
+ ku0=7.500000e-08          tku0=0.000000e+00         pku0=1.000000e-13
+ wku0=1.000000e-06         lku0=1.000000e-07         lu0=(-1.0348089e-009+dlu0p_5)*fu0misp_5
+ wu0=(-1.7398728e-009+dwu0p_5)*fu0misp_5             pu0=(7.1752592e-016+dpu0p_5)*fu0misp_5
+ ua=2.3261207e-009         lua=1.388319e-016         wua=-4.884073e-017
+ pua=4.5384312e-022        ub=2.3585763e-019         lub=-3.3380997e-025
+ wub=-6.4894281e-025       pub=-2.0069839e-031       uc=-6.2049654e-011
+ luc=1.3879556e-017        wuc=-3.3418663e-017       puc=-2.5063735e-024
+ vsat=77224.213            lvsat=-0.0013974218+dlvsatp_5
+ kvsat=-2.550000e-01       wvsat=-0.00011339778      pvsat=1.6286807e-009+dpvsatp_5
+ a0=1.3496687              la0=-4.7455973e-007+dla0p_5
+ wa0=-1.4216887e-007       pa0=3.1286588e-013        ags=0.12033563+dagsp_5
+ lags=1.7565756e-008       wags=-2.5443786e-008+dwagsp_5
+ pags=4.4072105e-014       a1=0                      a2=1
+ b0=0                      b1=0                      keta=0.0099759062
+ lketa=-1.5707511e-008     wketa=4.6420864e-009      pketa=-6.5632518e-015
+ dwg=0                     dwb=0                     pclm=0.30080965+dpclmp_5
+ lpclm=-1.4821721e-008     wpclm=-1.5922156e-008+dwpclmp_5
+ ppclm=1.5632373e-013      pdiblc1=0                 pdiblc2=0.00043820478+dpdiblc2p_5
+ lpdiblc2=7.1125491e-010   wpdiblc2=-2.4144955e-010  ppdiblc2=-6.4155169e-016
+ pdiblcb=-0.2              drout=0.56                pvag=0
+ delta=0.01                pscbe1=4.11e+008          pscbe2=1e-006
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.49                  rdsw=1000
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=205.43126          lalpha1=-0.00016556841
+ walpha1=-1.8808074e-005   palpha1=3.0606623e-011    beta0=50.181317+dbeta0p_5
+ lbeta0=-8.3843667e-006    wbeta0=-1.8914802e-007    pbeta0=1.62733e-012+dpbeta0p_5
+ agidl=5.5795472e-012      lagidl=4.1160644e-018     wagidl=-7.975292e-019
+ pagidl=4.0190831e-025     bgidl=1.0679e+009         cgidl=150
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgop_5               cgdo=cgop_5
+ cgbo=0                    cgdl=cglp_5               cgsl=cglp_5
+ clc=1e-007                cle=0.6                   cf=cfp_5
+ ckappas=0.6               ckappad=0.6               acde=1
+ moin=25                   noff=2                    voffcv=-0.02
+ tvoff=0.00270484          ltvoff=-1.31493e-009      wtvoff=-3.80588e-010
+ ptvoff=1.17045e-015       kt1=-0.36518645           lkt1=-3.154574e-008
+ wkt1=-7.1942316e-009      pkt1=1.7514003e-014       kt1l=0
+ kt2=-0.051165353          lkt2=3.9534766e-009       wkt2=-1.3660141e-008
+ pkt2=2.6933766e-015       ute=-1.2418355            lute=1.1791929e-007
+ wute=-7.5044313e-008      pute=6.1122578e-014       ua1=-1.7142151e-010
+ lua1=1.5910554e-015       wua1=-5.1277583e-016      pua1=-1.065637e-021
+ ub1=-9.6118651e-019       lub1=-3.5007403e-024      wub1=3.2397326e-025
+ pub1=2.4947955e-030       uc1=6.194552e-011         luc1=-1.0028855e-016
+ wuc1=3.4721348e-017       puc1=7.8679234e-023       prt=0
+ at=77144.435              lat=-0.070144066          wat=0.00049137779
+ pat=-4.8243471e-009+dpatp_5                         fnoimod=1
+ tnoimod=0                 em=1.192e+07              ef=1.13
+ noia=1.67e+41             noib=1.612e+24            noic=3.5e9
+ lintnoi=-1e-7             jss=1.94e-07              jsd=1.94e-07
+ jsws=7.03e-14             jswd=7.03e-14             jswgs=8.1e-14
+ jswgd=8.1e-14             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
