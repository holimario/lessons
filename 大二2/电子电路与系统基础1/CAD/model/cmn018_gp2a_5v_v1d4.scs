//                                                              *
// **************************************************************
// ***************** CORNER_LIB OF TYPICAL MODEL ****************************

section tt_bbmvar5
include "cmn018_gp2a_5v_v1d4.scs" section=setup_cap_5
parameters par5_nmoscap=0
parameters dxln_var5=0.000e+00
parameters dxwn_var5=0.000e+00
parameters cgminn_var5=1.000
parameters dcgn_var5=1.000
include "cmn018_gp2a_5v_v1d4.scs" section=bb_mvar5
endsection tt_bbmvar5
// ****************** CORNER_LIB OF SLOW MODEL ******************************

section ss_bbmvar5
include "cmn018_gp2a_5v_v1d4.scs" section=setup_cap_5
parameters par5_nmoscap=0
parameters dxln_var5=1.330e-08
parameters dxwn_var5=-2.200e-08
parameters cgminn_var5=0.900
parameters dcgn_var5=0.957
include "cmn018_gp2a_5v_v1d4.scs" section=bb_mvar5
endsection ss_bbmvar5
// ****************** CORNER_LIB OF FAST MODEL ******************************

section ff_bbmvar5
include "cmn018_gp2a_5v_v1d4.scs" section=setup_cap_5
parameters par5_nmoscap=0
parameters dxln_var5=-1.330e-08
parameters dxwn_var5=2.200e-08
parameters cgminn_var5=1.100
parameters dcgn_var5=1.043
include "cmn018_gp2a_5v_v1d4.scs" section=bb_mvar5
endsection ff_bbmvar5
// ****************** CORNER_LIB OF STATISTICAL MODEL ******************************

section mc_bbmvar5
include "cmn018_gp2a_5v_v1d4.scs" section=setup_cap_5
parameters par5_nmoscap=0
parameters a1_bbmvar5=par6 * 2.1
parameters dxln_var5=0.000e+00 + ( - 6.65e-009) * a1_bbmvar5
parameters dxwn_var5=0.000e+00 + (1.1e-008) * a1_bbmvar5
parameters cgminn_var5=1.000 + (0.05) * a1_bbmvar5
parameters dcgn_var5=1.000 + (0.0215) * a1_bbmvar5
include "cmn018_gp2a_5v_v1d4.scs" section=bb_mvar5
endsection mc_bbmvar5
 

section bb_mvar5
 
subckt nmoscap_5 ( ng nds ) 
parameters lr=1u wr=1u factor=1 mr=1 xl=3.000e-08 xw=-1.000e-08 area=(lr * factor 
+ - xl + dxln_var5) * (wr * factor - xw + dxwn_var5) cgmin=3.290e-10 * cgminn_var5 
+ * 2 * (wr * factor - xw + dxwn_var5) + 8.600e-11 * cgminn_var5 * 2 * (lr * factor 
+ - xl + dxln_var5) + 6.050e-04 * cgminn_var5 * area dcg=( - 1.820e-11) * dcgn_var5 
+ * 2 * (wr * factor - xw + dxwn_var5) + (2.100e-12) * dcgn_var5 * 2 * (lr * factor 
+ - xl + dxln_var5) + (9.510e-04) * dcgn_var5 * area dvgs0=-0.330 vgnorm0=0.602 
+ dvgs=dvgs0 + ( - 7.46e-04) * (temp - 25) vgnorm=vgnorm0 + (1.755e-03) * (temp 
+ - 25) 
 
cg ( ng nds ) bsource q=mr*((cgmin+dcg)*v(ng,nds)+vgnorm*dcg*ln(cosh((v(ng,nds)-dvgs)/vgnorm)))
ends nmoscap_5
 

subckt nmoscap_5_mis ( ng nds ) 
parameters lr=1u wr=1u factor=1 mr=1 mismatchflag=mismatchflag_cap5 xl=3.000e-08 
+ xw=-1.000e-08 area=(lr * factor - xl + dxln_var5) * (wr * factor - xw + dxwn_var5) 
+ cgmin=3.290e-10 * cgminn_var5 * 2 * (wr * factor - xw + dxwn_var5) + 8.600e-11 
+ * cgminn_var5 * 2 * (lr * factor - xl + dxln_var5) + 6.050e-04 * cgminn_var5 * 
+ area dcg=( - 1.820e-11) * dcgn_var5 * 2 * (wr * factor - xw + dxwn_var5) + (2.100e-12) 
+ * dcgn_var5 * 2 * (lr * factor - xl + dxln_var5) + (9.510e-04) * dcgn_var5 * area 
+ dvgs0=-0.330 vgnorm0=0.602 dvgs=dvgs0 + ( - 7.46e-04) * (temp - 25) vgnorm=vgnorm0 
+ + (1.755e-03) * (temp - 25) mis_a=0.442 mis_b=0.252 geo_fac=1 / sqrt(lr * wr 
+ * 1e12 * mr) factmis=geo_fac * par5_nmoscap * mismatchflag 
 
cg ( ng nds ) bsource q=mr*((cgmin+cgmin*0.01*(mis_a+mis_b)*factmis+dcg*(1+0.01*mis_a*factmis))*v(ng,nds)- vgnorm0
+ *cgmin*0.01*mis_b*factmis*log(cosh((v(ng,nds)+dVgs0)/Vgnorm0)) + vgnorm
+ *dcg*(1+0.01*mis_a*factmis)*log(cosh((v(ng,nds)-dvgs)/vgnorm)))
 
 
ends nmoscap_5_mis
endsection bb_mvar5
 
 
// *******************************************************************************
// 
//  MIM Capacitor Model
// 
// *******************************************************************************
 

section stat_mim
parameters mimrandom1=0
parameters mimpar1=mimrandom1

statistics {
    process {
        vary mimrandom1 dist=gauss std=1/1
        }
    }
endsection stat_mim
 

section tt_mim
include "cmn018_gp2a_5v_v1d4.scs" section=setup_mim
parameters par_mim=0
parameters cmimbb_mimfac=1.0
parameters cm5bb_mimfac=1.0
include "cmn018_gp2a_5v_v1d4.scs" section=mim
endsection tt_mim
 

section ff_mim
include "cmn018_gp2a_5v_v1d4.scs" section=setup_mim
parameters par_mim=0
parameters cmimbb_mimfac=0.85
parameters cm5bb_mimfac=0.9538
include "cmn018_gp2a_5v_v1d4.scs" section=mim
endsection ff_mim
 

section ss_mim
include "cmn018_gp2a_5v_v1d4.scs" section=setup_mim
parameters par_mim=0
parameters cmimbb_mimfac=1.15
parameters cm5bb_mimfac=1.052
include "cmn018_gp2a_5v_v1d4.scs" section=mim
endsection ss_mim
 

section mc_mim
include "cmn018_gp2a_5v_v1d4.scs" section=setup_mim
parameters par_mim=0
parameters cmimbb_mimfac=1.0 + 0.05 * mimpar1
parameters cm5bb_mimfac=1.0
include "cmn018_gp2a_5v_v1d4.scs" section=mim
endsection mc_mim
 
 

section mim
// *************************************************************************************************
//  2) MIM BaseBand CAPACITOR MODEL :
// 
// 
//      ## library files:
//      
//      1. The BB 1.0fF MIM capacitors without Shield are modeled with 2T sub-circuit 
//  'mimcap_1p0_sin'      
// 
//       .subckt mimcap_1p0_sin : Typical model,  
// 
//      2. The BB 1.0fF MIM capacitors without Shield are modeled with 3T sub-circuit 
//  'mimcap_1p0_sin_3t'      
// 
//       .subckt mimcap_1p0_sin_3t : Typical model,  
//      
//      3. The BB 2.0fF MIM capacitors without Shield are modeled with 2T sub-circuit 
//  'mimcap_2p0_sin'      
// 
//       .subckt mimcap_2p0_sin : Typical model,  
// 
//      4. The BB 2.0fF MIM capacitors without Shield are modeled with 3T sub-circuit 
//  'mimcap_2p0_sin_3t'      
// 
//       .subckt mimcap_2p0_sin_3t : Typical model,  
//       
//       
//             Model name                     lt                wt          unit
//                                        low    high       low    high
//             -------------------------------------------------------------------
//             mimcap_1p0_sin              4      30         4      30       um
//             mimcap_1p0_sin_3t           4      30         4      30       um
//             mimcap_2p0_sin              4      30         4      30       um
//             mimcap_2p0_sin_3t           4      30         4      30       um
//             -------------------------------------------------------------------
//             **lt: length dimension of top metal
//             **wt: width dimension of top metal
//             **lt >= wt
//             **lay: metal layer number of stack-up, such as 1P6M, lay=6.
//         The CTM enclosure by CBM with 0.4um/per side is based on the minimum 
//  design rule 
//         for parasitic capacitance pre-simulation in PDK.
//             
// *************************************************************************************************
// *************************** 2 T 1p0 MiM cap ********************************************
subckt mimcap_1p0_sin ( top bottom ) 
parameters lt=10u wt=10u factor=1 mf=1 mismatchflag=mismatchflag_mim geo_fac=1 / 
+ sqrt(mf * lt * factor * wt * factor * 1e12) factmis=0.0181 * geo_fac * par_mim 
+ * mismatchflag cmim_para=(1 + factmis) * (((wt * factor + 0.011u) * (lt * factor 
+ + 0.011u) * 1e12 * 1.0) + 2 * ((wt * factor + 0.011u) + (lt * factor + 0.011u)) 
+ * 1e6 * 0.13) * 1e-15 * (1 + (temp - 25) *  - 3.75279e-5 + (temp - 25) ** 
+ 2 *  - 6.66927e-9) 
 
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*6.88271e-5+1/3*v(top,bottom)**3*-2.20387e-5)*cmimbb_mimfac*mf
 
ends mimcap_1p0_sin
 
// *************************** 3 T 1p0 MiM cap ********************************************
subckt mimcap_1p0_sin_3t ( top bottom gnode ) 
parameters lt=10u wt=10u lay=6 factor=1 mf=1 mismatchflag=mismatchflag_mim geo_fac=1 
+ / sqrt(mf * lt * factor * wt * factor * 1e12) factmis=0.0181 * geo_fac * par_mim 
+ * mismatchflag cmim_para=(1 + factmis) * (((wt * factor + 0.011u) * (lt * factor 
+ + 0.011u) * 1e12 * 1.0) + 2 * ((wt * factor + 0.011u) + (lt * factor + 0.011u)) 
+ * 1e6 * 0.13) * 1e-15 * (1 + (temp - 25) *  - 3.75279e-5 + (temp - 25) ** 
+ 2 *  - 6.66927e-9) cox_para=((lt * factor * 1e6 + 0.8) * (wt * factor * 1e6 + 
+ 0.8) * 0.005071 + 2 * ((lt * factor * 1e6 + 0.8) + (wt * factor * 1e6 + 0.8)) 
+ * 0.0112) * 1e-15 
 
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*6.88271e-5+1/3*v(top,bottom)**3*-2.20387e-5)*cmimbb_mimfac*mf
 
cox ( bottom gnode ) capacitor c=cox_para * ((1 / (15.90757 + (4.14141672) * (lay 
+ - 4))) / 0.041337843) * cm5bb_mimfac * mf
// 
ends mimcap_1p0_sin_3t
 
// *************************** 2 T 2p0 MiM cap ********************************************
subckt mimcap_2p0_sin ( top bottom ) 
parameters lt=10u wt=10u factor=1 mf=1 mismatchflag=mismatchflag_mim geo_fac=1 / 
+ sqrt(mf * lt * factor * wt * factor * 1e12) factmis=0.008586 * geo_fac * par_mim 
+ * mismatchflag cmim_para=(1 + factmis) * (((wt * factor - 0.01352u) * (lt * factor 
+ - 0.01352u) * 1e12 * 1.9804) + 2 * ((wt * factor - 0.01352u) + (lt * factor - 
+ 0.01352u)) * 1e6 * 0.1090) * 1e-15 * (1 + (temp - 25) * 2.7153e-5 + (temp 
+ - 25) ** 2 * 2.9486e-8) 
 
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*7.7898e-6+1/3*v(top,bottom)**3*9.1979e-6)*cmimbb_mimfac*mf
 
ends mimcap_2p0_sin
 
// *************************** 3 T 2p0 MiM cap ********************************************
subckt mimcap_2p0_sin_3t ( top bottom gnode ) 
parameters lt=10u wt=10u lay=6 factor=1 mf=1 mismatchflag=mismatchflag_mim geo_fac=1 
+ / sqrt(mf * lt * factor * wt * factor * 1e12) factmis=0.008586 * geo_fac * par_mim 
+ * mismatchflag cmim_para=(1 + factmis) * (((wt * factor - 0.01352u) * (lt * factor 
+ - 0.01352u) * 1e12 * 1.9804) + 2 * ((wt * factor - 0.01352u) + (lt * factor - 
+ 0.01352u)) * 1e6 * 0.1090) * 1e-15 * (1 + (temp - 25) * 2.7153e-5 + (temp 
+ - 25) ** 2 * 2.9486e-8) cox_para=((lt * factor * 1e6 + 0.8) * (wt * factor * 1e6 
+ + 0.8) * 0.005071 + 2 * ((lt * factor * 1e6 + 0.8) + (wt * factor * 1e6 + 0.8)) 
+ * 0.0114) * 1e-15 
 
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*7.7898e-6+1/3*v(top,bottom)**3*9.1979e-6)*cmimbb_mimfac*mf
 
cox ( bottom gnode ) capacitor c=cox_para * ((1 / (11.41604 + (4.141672) * (lay 
+ - 4))) / 0.050763) * cm5bb_mimfac * mf
// 
ends mimcap_2p0_sin_3t
 
endsection mim
 
 
// **********************************************************************
//              	              RTMOM                                   *
// **********************************************************************
// ************ Library of typical corner *******************************
 

section tt_rtmom
include "cmn018_gp2a_5v_v1d4.scs" section=setup_rtmom
parameters rtmom_fac=1
parameters par_mom=0
include "cmn018_gp2a_5v_v1d4.scs" section=rtmom
endsection tt_rtmom
 
// ************ Library of slow corner **********************************
 

section ss_rtmom
include "cmn018_gp2a_5v_v1d4.scs" section=setup_rtmom
parameters rtmom_fac=1.25
parameters par_mom=0
include "cmn018_gp2a_5v_v1d4.scs" section=rtmom
endsection ss_rtmom
 
// ************ Library of fast corner **********************************
 

section ff_rtmom
include "cmn018_gp2a_5v_v1d4.scs" section=setup_rtmom
parameters rtmom_fac=0.75
parameters par_mom=0
include "cmn018_gp2a_5v_v1d4.scs" section=rtmom
endsection ff_rtmom
 
// ************ Library of MC corner **********************************
 

section mc_rtmom
include "cmn018_gp2a_5v_v1d4.scs" section=setup_rtmom
parameters rtmom_fac=1.0 + 0.0625 * mompar
parameters par_mom=0
include "cmn018_gp2a_5v_v1d4.scs" section=rtmom
endsection mc_rtmom
 
// ***********************************************************************
 

section rtmom
// *****************************************************************************************
//                                                                            
//               *
//            018 BB RTMOM                                                    
//               *
//                                                                            
//               *
//            parameter range: nv : 6~288, nh : 6~288                         
//               *
//                             nv and nh should be even fingers               
//               *
//                             w(width):0.28u ~0.32u                          
//               *
//                             s(spacing):0.28u ~0.32u                        
//               *
//                             stm(start metal layer):M1,M2,M3                
//               *
//                             spm(stop metal layer):M3,M4,M5                 
//               *
//                             Total metal is at least 3 layers stacked with ploy 
//  shield   *
//                             mismatchflag : 0 represents no mis-match       
//               *
//                                            1 represents Parallel mis-match 
//               *
//                                                                            
//               *
//                                                                            
//               *
// *****************************************************************************************
subckt crtmom ( a b p ) 
parameters nv=32 nh=32 w=0.28u s=0.28u stm=1 spm=5 factor=1 mf=1 mismatchflag=mismatchflag_rtmom 
+ layno=spm - stm + 1 laym1=int(layno / spm) layodd=int((layno + (stm - 2) * (stm 
+ - 3) * (stm - 4) * (stm - 5) / (24) + (stm - 1) * (stm - 2) * (stm - 4) * (stm 
+ - 5) / (4) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 4) / 24) / 2) - laym1 
+ layeven=int((layno + (stm - 1) * (stm - 3) * (stm - 4) * (stm - 5) / ( - 6) + 
+ (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / ( - 6)) / 2) edg=((layodd + 5300 
+ / 5300 * laym1) * (nv - 1) * (nh * (w * factor + s * factor) - s * factor) + layeven 
+ * (nh - 1) * (nv * (w * factor + s * factor) - s * factor)) area=nv * nh / 2 * 
+ w * factor * (layno - 1) fri1=(2 * nh * nv * w * factor) * (layno - 1) fri2=((layodd 
+ + laym1) * nv * w * factor + layeven * nh * w * factor) + layeven * (nv * (w * 
+ factor + s * factor) - s * factor + 0.5u) * 2 + layno * 0.28u * 2 + (layodd + 
+ 5300 / 5300 * laym1) * (nh * (w * factor + s * factor) - s * factor) * 2 abm=((nv 
+ * (w * factor + s * factor) - s * factor + (0.28u + 0.5u) * 2) + (nh * (w * factor 
+ + s * factor) - s * factor + 0.5u)) * 0.28u afm=(nv * w * factor * (nh * (w * 
+ factor + s * factor) - s * factor + 0.5u)) / 2 pf=(nh * (w * factor + s * factor) 
+ - s * factor + 0.5u) * (nv) * 2 / 2 + 2 * ((nv * (w * factor + s * factor) - s 
+ * factor + (0.5u + 0.28u) * 2) + (nh * (w * factor + s * factor) - s * factor 
+ + 0.5u + 0.28u)) pfb=((nh * (w * factor + s * factor) - s * factor) + 0.5u + 0.28u) 
+ * 2.7 cc1=0.023964608 / (s * factor * 1e6) - 0.000227392 / (w * factor * 1e6) 
+ - 0.000501253 / (s * factor * 1e6) / (w * factor * 1e6) + 0.008322715 cc2=0.0497 
+ cf=0.015000000 * (s * factor * 1e6) - 0.002500000 * (w * factor * 1e6) + 0.006250000 
+ * (s * factor * 1e6) * (w * factor * 1e6) + 0.001339500 ca=0.000000000 * (s * 
+ factor * 1e6) + 0.040000000 * (w * factor * 1e6) + 0.000000000 * (s * factor * 
+ 1e6) * (w * factor * 1e6) - 0.000100000 ca_p_a=((stm - 2) * (stm - 3) / (1 - 2) 
+ / (1 - 3) * (0.000000000) + (stm - 1) * (stm - 3) / (2 - 1) / (2 - 3) * (0.000000000) 
+ + (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * (0.000000000)) ca_p_b=((stm - 2) 
+ * (stm - 3) / (1 - 2) / (1 - 3) * (0.065000000) + (stm - 1) * (stm - 3) / (2 - 
+ 1) / (2 - 3) * (0.017500000) + (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * (0.010250000)) 
+ ca_p_c=((stm - 2) * (stm - 3) / (1 - 2) / (1 - 3) * (0.000000000) + (stm - 1) 
+ * (stm - 3) / (2 - 1) / (2 - 3) * (0.000000000) + (stm - 1) * (stm - 2) / (3 - 
+ 1) / (3 - 2) * (0.000000000)) ca_p_d=((stm - 2) * (stm - 3) / (1 - 2) / (1 - 3) 
+ * (0.000100000) + (stm - 1) * (stm - 3) / (2 - 1) / (2 - 3) * (0.000040000) + 
+ (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * ( - 0.000019000)) cf_p_a=((stm - 2) 
+ * (stm - 3) / (1 - 2) / (1 - 3) * (0.031750000) + (stm - 1) * (stm - 3) / (2 - 
+ 1) / (2 - 3) * (0.005750000) + (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * (0.002750000)) 
+ cf_p_b=((stm - 2) * (stm - 3) / (1 - 2) / (1 - 3) * (0.006000000) + (stm - 1) 
+ * (stm - 3) / (2 - 1) / (2 - 3) * ( - 0.002500000) + (stm - 1) * (stm - 2) / (3 
+ - 1) / (3 - 2) * ( - 0.002250000)) cf_p_c=((stm - 2) * (stm - 3) / (1 - 2) / (1 
+ - 3) * ( - 0.018750001) + (stm - 1) * (stm - 3) / (2 - 1) / (2 - 3) * (0.006250000) 
+ + (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * (0.006250000)) cf_p_d=((stm - 2) 
+ * (stm - 3) / (1 - 2) / (1 - 3) * ( - 0.000779500) + (stm - 1) * (stm - 3) / (2 
+ - 1) / (2 - 3) * (0.001288500) + (stm - 1) * (stm - 2) / (3 - 1) / (3 - 2) * (0.001129500)) 
+ ca_p=(ca_p_a * (s * factor * 1e6) + ca_p_b * (w * factor * 1e6) + ca_p_c * (s 
+ * factor * 1e6) * (w * factor * 1e6) + ca_p_d) cf_p=cf_p_a * (s * factor * 1e6) 
+ + cf_p_b * (w * factor * 1e6) + cf_p_c * (s * factor * 1e6) * (w * factor * 1e6) 
+ + cf_p_d cc_p=0.0451 slope_mis=(0.01611) geo_fac=1 / sqrt(((cc1 * edg * 1e-9 + 
+ cf * 1e-9 * fri1 + ca * 1e-9 * area + cc2 * 1e-9 * fri2) + (ca_p * (abm + afm) 
+ / (w * factor * 1e6) * 1e-3 + cf_p * pf * 1e-9 + cc_p * pfb * 1e-9)) * 1e15 * 
+ mf) factmis=slope_mis * geo_fac * par_mom * mismatchflag 
// 
cab ( a b ) bsource q=(1+factmis)*(cc1*edg*1e-9+cf*1e-9*fri1+ca*1e-9*area+cc2*1e-9*fri2)*(1+(temp-25)*(30.05*1e-6)+(temp-25)*(temp-25)*(-9e-8))*(v(a,b)-1*1e-6*1/2*v(a,b)**2+0.5*1e-6*1/3*v(a,b)**3)*mf*rtmom_fac
cpa ( a p ) bsource q=(1+factmis)*(ca_p*(abm+afm)/(w*factor*1e6)*1e-3+cf_p*pf*1e-9+cc_p*pfb*1e-9)*(1+(temp-25)*(30.05*1e-6)+(temp-25)*(temp-25)*(-9e-8))*(v(a,p)-1*1e-6*1/2*v(a,p)**2+0.5*1e-6*1/3*v(a,p)**3)*mf*rtmom_fac
cpb ( b p ) bsource q=(1+factmis)*(ca_p*(abm+afm)/(w*factor*1e6)*1e-3+cf_p*pf*1e-9+cc_p*pfb*1e-9)*(1+(temp-25)*(30.05*1e-6)+(temp-25)*(temp-25)*(-9e-8))*(v(b,p)-1*1e-6*1/2*v(b,p)**2+0.5*1e-6*1/3*v(b,p)**3)*mf*rtmom_fac
ends crtmom
 
endsection rtmom
 
// **********************************************************************
//              	              FMOM                                    *
// **********************************************************************
// ************ Library of typical corner *******************************

section tt_fmom
include "cmn018_gp2a_5v_v1d4.scs" section=setup_fmom
parameters par_fmom=0
parameters par_fmom1=0
parameters par_fmom2=0
parameters fmom_fac=1
parameters fmom_fac2=1
include "cmn018_gp2a_5v_v1d4.scs" section=fmom
endsection tt_fmom
 
// ************ Library of slow corner **********************************

section ss_fmom
include "cmn018_gp2a_5v_v1d4.scs" section=setup_fmom
parameters par_fmom=0
parameters par_fmom1=0
parameters par_fmom2=0
parameters fmom_fac=1.2
parameters fmom_fac2=1.4
include "cmn018_gp2a_5v_v1d4.scs" section=fmom
endsection ss_fmom
 
// ************ Library of fast corner **********************************

section ff_fmom
include "cmn018_gp2a_5v_v1d4.scs" section=setup_fmom
parameters par_fmom=0
parameters par_fmom1=0
parameters par_fmom2=0
parameters fmom_fac=0.8
parameters fmom_fac2=0.6
include "cmn018_gp2a_5v_v1d4.scs" section=fmom
endsection ff_fmom
 
// ************ Library of MC corner **********************************

section mc_fmom
include "cmn018_gp2a_5v_v1d4.scs" section=setup_fmom
parameters par_fmom=0
parameters par_fmom1=0
parameters par_fmom2=0
parameters a1_mom=mompar * 1.0000e+000 / 3
parameters fmom_fac=1.0000e+000 + (2.0000e-001) * a1_mom
parameters fmom_fac2=1.0000e+000 + (4.0000e-001) * a1_mom
 
include "cmn018_gp2a_5v_v1d4.scs" section=fmom
endsection mc_fmom
// ******************************************************************************************

section fmom
// ******************************************************************************************
//                                                                            
//                *
// 0.18umBB FMOM                                                              
//     		  *
//                                                                            
//                *
//            parameter range: nr :8~290(should be even fingers)				  *
//                             lr :3u ~ 168u						  *
//                             w(width):0.28u ~ 0.32u				    	  *
//                             s(spacing):0.28u ~ 0.32u					  *
//                             stm(start metal layer):M1,M2,M3                
//       	  *
//                             spm(stop metal layer):M3,M4,M5                 
//     		  *
//                             Total metal is at least 3 layers stacked with ploy 
//  shield    *
//              		     L Bus metal width (with via) : 0.28um (Non scalable)   
//        *
//              		     Dummy Bus Width = finger width                         
//        *
//               		     Dummy Bus Space = finger space                        
//         *
//                             Ftip = 0.5um (Non scalable)          	         
//           *
//                             Distance between DBW and pickup metal : 0.5um (Non 
//  scalable) *
//                             mismatchflag=0 for no mismatch                 
//                *
//                             mismatchflag=1 for parallel                    
//                *
//                                                                            
//                *
// ******************************************************************************************
 
subckt cfmom ( a b p ) 
parameters nr=8 lr=167.5u w=0.32u s=0.32u stm=2 spm=5 mf=1 factor=1 mismatchflag=mismatchflag_fmom 
+ ww=w * 1e6 * factor ss=s * 1e6 * factor ll=lr * 1e6 * factor layno=spm - stm + 
+ 1 lnr=nr * (ww + ss) - ss j1=(stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) * (stm 
+ - 6) / (1 - 2) / (1 - 3) / (1 - 4) / (1 - 5) / (1 - 6) j2=(stm - 1) * (stm - 3) 
+ * (stm - 4) * (stm - 5) * (stm - 6) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) / 
+ (2 - 6) j3=(stm - 1) * (stm - 2) * (stm - 4) * (stm - 5) * (stm - 6) / (3 - 1) 
+ / (3 - 2) / (3 - 4) / (3 - 5) / (3 - 6) tcc1=24.002 * 1e-6 tcc2=0.033 * 1e-6 vcc1=0.6976 
+ * 1e-6 vcc2= - 0.5168 * 1e-6 tfac=1 + tcc1 * (temp - 25) + tcc2 * (temp - 
+ 25) * (temp - 25) wb=0.28 * 1e-6 ftip=0.5 * 1e-6 cfg=((1.58502456697802e-03 
+ / ww + 4.97834615382138e-02 / ss +  - 8.69991468352519e-03 / ww / ss + 0.141092575577826)) 
+ * (0.887) cfg_t=(( - 1.45133875490407e-03 / ww + 0.051901629507603 / ss +  - 1.7164057841426e-03 
+ / ww / ss + 0.058158748650859)) * (0.86) cfg_b=(( - 7.51670687057387e-04 / ww 
+ + 5.19814417344521e-02 / ss +  - 1.45077745025167e-03 / ww / ss + 4.69794855516748e-02)) 
+ * (0.92) cfg_b_m1=((6.65867866332224e-04 / ww + 5.27140572153396e-02 / ss +  - 
+ 1.35294557061935e-03 / ww / ss + 0.021114140335185)) * (1) cfge=(( - 3.58921897506737e-03 
+ / ww + 2.17531337273711e-02 / ss + 2.22078239338076e-04 / ww / ss + 3.39251743618729e-02)) 
+ * (1.03) cfge_t=(( - 2.067472379465e-04 / ww + 1.89594574185258e-02 / ss +  - 
+ 5.90024678651475e-04 / ww / ss + 4.78083405448536e-02)) * (0.59) cfge_b=(( - 4.08481609189726e-03 
+ / ww + 2.07839555057359e-02 / ss + 5.31365394776244e-04 / ww / ss + 3.24968359914656e-02)) 
+ * (1.19) cfge_b_m1=((2.0613984133751e-03 / ww + 2.68051143896327e-02 / ss +  - 
+ 1.14880307083888e-03 / ww / ss + 1.08626496746679e-03)) * (1) cbus=(0.066188) 
+ * (1.52) cbus_t=(0.070721) * (1) cbus_b=(0.062123) * (1.62) cbus_b_m1=(0.052392) 
+ * (1) cfinger=((layno - 2) * cfg + cfg_t + cfg_b * (j2 + j3) + cfg_b_m1 * j1) 
+ / 2 * (nr - 3) * ll cedge=((layno - 2) * cfge + cfge_t + cfge_b * (j2 + j3) + 
+ cfge_b_m1 * j1) * ll * 2 cedge2=((layno - 2) * cbus + cbus_t + cbus_b * (j2 + 
+ j3) + cbus_b_m1 * j1) * nr * ww cp_m1fg=j1 * (7.07541668838077e-02 * ww + 6.21037700315025e-02 
+ * ss + 6.24999341603259e-04 * ww * ss + 1.28949596878795e-03) * 0.988 cp_m2fg=j2 
+ * (1.80585317457402e-02 * ww + 1.73843253965345e-02 * ss +  - 2.97619037915623e-05 
+ * ww * ss + 8.04933863307867e-05) * 1.103 cp_m3fg=j3 * (1.03166466568724e-02 * 
+ ww + 1.00910117360319e-02 * ss + 5.05958000334281e-05 * ww * ss + 3.52388072156329e-05) 
+ * 1.116 cp_m1fge=j1 * (0.135273359618694 * ww + 1.35405398464984e-02 * ss +  - 
+ 0.247736013611283 * ww * ss +  - 2.34920544459968e-03) * 1 cp_m2fge=j2 * (9.96401910145081e-04 
+ * ww +  - 4.1542717932859e-03 * ss +  - 8.39105828027469e-05 * ww * ss + 1.56738096602432e-02) 
+ * 0.881 cp_m3fge=j3 * (6.16953923242438e-03 * ww + 1.87598430851836e-03 * ss + 
+ 8.26070374619411e-03 * ww * ss +  - 8.46620765503368e-04) * 3.178 cp_fg=(cp_m1fg 
+ + cp_m2fg + cp_m3fg) * 0.828 cp_fge=(cp_m1fge + cp_m2fge + cp_m3fge) * 3.85 cpb=j1 
+ * (0.072592) * (1) + j2 * (0.035557) * (0.75) + j3 * (0.020533) * (0.868) cm1pk=(0.072592) 
+ * (1) cp_finger=(cp_fg * (nr / 2 - 1) + cp_fge) * (ll + ftip * 1e6) cp_bus=cpb 
+ * lnr * 0.651 cp_pk=j1 * cm1pk * (ll + ftip * 1e6 + 2 * wb * 1e6) mis=((mismatchflag 
+ - 1) / (0 - 1) * (0) + (mismatchflag - 0) / (1 - 0) * (2.3014)) geo_fac=1 / sqrt((cfinger 
+ + cedge + cedge2) * mf) factmis=mis / 1.414 / 100 * par_fmom * geo_fac 
// 
// 
cab ( a b ) bsource q=(1+factmis)*(cfinger+cedge+cedge2)*(tfac)*(v(a,b)+vcc1*1/2*v(a,b)**2+vcc2*1/3*v(a,b)**3)*1e-15*mf*fmom_fac
cpa ( a p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(a,p)+vcc1*1/2*v(a,p)**2+vcc2*1/3*v(a,p)**3)*1e-15*mf*fmom_fac2
cpb ( b p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(b,p)+vcc1*1/2*v(b,p)**2+vcc2*1/3*v(b,p)**3)*1e-15*mf*fmom_fac2
 
ends cfmom
 
// ******************************************************************************************
//                                                                            
//                *
// 0.18umBB FMOM   MULTI-X-COUPLE MISMATCH APPLICATION                        
//   		  *
// (FMOM multi-x-couple type device is only valid in array number=2)  		      
//      *
//            parameter range: nr :8~290(should be even fingers)				  *
//                             lr :3u ~ 168u						  *
//                             w(width):0.28u ~ 0.32u				    	  *
//                             s(spacing):0.28u ~ 0.32u					  *
//                             stm(start metal layer):M1,M2,M3                
//       	  *
//                             spm(stop metal layer):M3,M4,M5                 
//     		  *
//                             Total metal is at least 3 layers stacked with ploy 
//  shield    *
//              		     L Bus metal width (with via) : 0.28um (Non scalable)   
//        *		
//              		     Dummy Bus Width = finger width                         
//        *		
//               		     Dummy Bus Space = finger space                        
//         *			
//                             Ftip = 0.5um (Non scalable)          	         
//           *
//                             Distance between DBW and pickup metal : 0.5um (Non 
//  scalable) *
//                             mismatchflag=0 for no mismatch                 
//                *
//                             mismatchflag=1 for multi-x-couple              
//                *
//                                                                            
//                *
// ******************************************************************************************
 
subckt cfmom_mx ( a b a1 b1 p ) 
parameters nr=8 lr=167.5u w=0.32u s=0.32u stm=2 spm=5 mf=1 factor=1 mismatchflag=mismatchflag_fmom 
+ ww=w * 1e6 * factor ss=s * 1e6 * factor ll=lr * 1e6 * factor layno=spm - stm + 
+ 1 lnr=nr * (ww + ss) - ss j1=(stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) * (stm 
+ - 6) / (1 - 2) / (1 - 3) / (1 - 4) / (1 - 5) / (1 - 6) j2=(stm - 1) * (stm - 3) 
+ * (stm - 4) * (stm - 5) * (stm - 6) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) / 
+ (2 - 6) j3=(stm - 1) * (stm - 2) * (stm - 4) * (stm - 5) * (stm - 6) / (3 - 1) 
+ / (3 - 2) / (3 - 4) / (3 - 5) / (3 - 6) tcc1=24.002 * 1e-6 tcc2=0.033 * 1e-6 vcc1=0.6976 
+ * 1e-6 vcc2= - 0.5168 * 1e-6 tfac=1 + tcc1 * (temp - 25) + tcc2 * (temp - 
+ 25) * (temp - 25) wb=0.28 * 1e-6 ftip=0.5 * 1e-6 cfg=((1.58502456697802e-03 
+ / ww + 4.97834615382138e-02 / ss +  - 8.69991468352519e-03 / ww / ss + 0.141092575577826)) 
+ * (0.887) cfg_t=(( - 1.45133875490407e-03 / ww + 0.051901629507603 / ss +  - 1.7164057841426e-03 
+ / ww / ss + 0.058158748650859)) * (0.86) cfg_b=(( - 7.51670687057387e-04 / ww 
+ + 5.19814417344521e-02 / ss +  - 1.45077745025167e-03 / ww / ss + 4.69794855516748e-02)) 
+ * (0.92) cfg_b_m1=((6.65867866332224e-04 / ww + 5.27140572153396e-02 / ss +  - 
+ 1.35294557061935e-03 / ww / ss + 0.021114140335185)) * (1) cfge=(( - 3.58921897506737e-03 
+ / ww + 2.17531337273711e-02 / ss + 2.22078239338076e-04 / ww / ss + 3.39251743618729e-02)) 
+ * (1.03) cfge_t=(( - 2.067472379465e-04 / ww + 1.89594574185258e-02 / ss +  - 
+ 5.90024678651475e-04 / ww / ss + 4.78083405448536e-02)) * (0.59) cfge_b=(( - 4.08481609189726e-03 
+ / ww + 2.07839555057359e-02 / ss + 5.31365394776244e-04 / ww / ss + 3.24968359914656e-02)) 
+ * (1.19) cfge_b_m1=((2.0613984133751e-03 / ww + 2.68051143896327e-02 / ss +  - 
+ 1.14880307083888e-03 / ww / ss + 1.08626496746679e-03)) * (1) cbus=(0.066188) 
+ * (1.52) cbus_t=(0.070721) * (1) cbus_b=(0.062123) * (1.62) cbus_b_m1=(0.052392) 
+ * (1) cfinger=((layno - 2) * cfg + cfg_t + cfg_b * (j2 + j3) + cfg_b_m1 * j1) 
+ / 2 * (nr - 3) * ll cedge=((layno - 2) * cfge + cfge_t + cfge_b * (j2 + j3) + 
+ cfge_b_m1 * j1) * ll * 2 cedge2=((layno - 2) * cbus + cbus_t + cbus_b * (j2 + 
+ j3) + cbus_b_m1 * j1) * nr * ww cp_m1fg=j1 * (7.07541668838077e-02 * ww + 6.21037700315025e-02 
+ * ss + 6.24999341603259e-04 * ww * ss + 1.28949596878795e-03) * 0.988 cp_m2fg=j2 
+ * (1.80585317457402e-02 * ww + 1.73843253965345e-02 * ss +  - 2.97619037915623e-05 
+ * ww * ss + 8.04933863307867e-05) * 1.103 cp_m3fg=j3 * (1.03166466568724e-02 * 
+ ww + 1.00910117360319e-02 * ss + 5.05958000334281e-05 * ww * ss + 3.52388072156329e-05) 
+ * 1.116 cp_m1fge=j1 * (0.135273359618694 * ww + 1.35405398464984e-02 * ss +  - 
+ 0.247736013611283 * ww * ss +  - 2.34920544459968e-03) * 1 cp_m2fge=j2 * (9.96401910145081e-04 
+ * ww +  - 4.1542717932859e-03 * ss +  - 8.39105828027469e-05 * ww * ss + 1.56738096602432e-02) 
+ * 0.881 cp_m3fge=j3 * (6.16953923242438e-03 * ww + 1.87598430851836e-03 * ss + 
+ 8.26070374619411e-03 * ww * ss +  - 8.46620765503368e-04) * 3.178 cp_fg=(cp_m1fg 
+ + cp_m2fg + cp_m3fg) * 0.828 cp_fge=(cp_m1fge + cp_m2fge + cp_m3fge) * 3.85 cpb=j1 
+ * (0.072592) * (1) + j2 * (0.035557) * (0.75) + j3 * (0.020533) * (0.868) cm1pk=(0.072592) 
+ * (1) cp_finger=(cp_fg * (nr / 2 - 1) + cp_fge) * (ll + ftip * 1e6) cp_bus=cpb 
+ * lnr * 0.651 cp_pk=j1 * cm1pk * (ll + ftip * 1e6 + 2 * wb * 1e6) mis=((mismatchflag 
+ - 1) / (0 - 1) * (0) + (mismatchflag - 0) / (1 - 0) * (0.6796)) geo_fac=1 / sqrt((cfinger 
+ + cedge + cedge2) * mf) factmis1=mis / 1.414 / 100 * par_fmom1 * geo_fac factmis2=mis 
+ / 1.414 / 100 * par_fmom2 * geo_fac 
// 
// 
cab ( a b ) bsource q=(1+factmis1)*(cfinger+cedge+cedge2)*(tfac)*(v(a,b)+vcc1*1/2*v(a,b)**2+vcc2*1/3*v(a,b)**3)*1e-15*mf*fmom_fac
cpa ( a p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(a,p)+vcc1*1/2*v(a,p)**2+vcc2*1/3*v(a,p)**3)*1e-15*mf*fmom_fac2
cpb ( b p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(b,p)+vcc1*1/2*v(b,p)**2+vcc2*1/3*v(b,p)**3)*1e-15*mf*fmom_fac2
 
ca1b1 ( a1 b1 ) bsource q=(1+factmis2)*((cfinger+cedge+cedge2)*(tfac)*(v(a1,b1)+vcc1*1/2*v(a1,b1)**2+vcc2*1/3*v(a1,b1)**3)*1e-15*mf*fmom_fac)
cpa1 ( a1 p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(a1,p)+vcc1*1/2*v(a1,p)**2+vcc2*1/3*v(a1,p)**3)*1e-15*mf*fmom_fac2
cpb1 ( b1 p ) bsource q=(cp_finger+cp_bus+cp_pk)*(tfac)*(v(b1,p)+vcc1*1/2*v(b1,p)**2+vcc2*1/3*v(b1,p)**3)*1e-15*mf*fmom_fac2
 
ends cfmom_mx
 
endsection fmom
// ************************************************************************
// ************ Schottky Barrier Diode Model Corner Parameters ************
// ************************************************************************
// **************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_sbd_mac
parameters is_d_sbd=1
parameters n_d_sbd=1
parameters x_jsw_sbd=0
parameters rs_d_sbd=1
parameters cj_d_sbd=1
parameters cjsw_d_sbd=1
include "cmn018_gp2a_5v_v1d4.scs" section=dio_sbd_mac
endsection tt_dio_sbd_mac
 
// **************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_sbd_mac
parameters is_d_sbd=0.7
parameters n_d_sbd=0.9975
parameters x_jsw_sbd=-1
parameters rs_d_sbd=1.2
parameters cj_d_sbd=1.07
parameters cjsw_d_sbd=1.07
include "cmn018_gp2a_5v_v1d4.scs" section=dio_sbd_mac
endsection ss_dio_sbd_mac
 
// **************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_sbd_mac
parameters is_d_sbd=1.3
parameters n_d_sbd=1.0025
parameters x_jsw_sbd=1
parameters rs_d_sbd=0.8
parameters cj_d_sbd=0.93
parameters cjsw_d_sbd=0.93
include "cmn018_gp2a_5v_v1d4.scs" section=dio_sbd_mac
endsection ff_dio_sbd_mac
 
// ****************************************************************************
//    
//  CMOS 0.18um 5V Schottky Barrier Diode (SBD) Scalable Model
// 
//  HSPICE LEVEL 49:
//   
//      ## library files:
//         Model Name     Length, l(um)    Width, w(um)     Finger Number, nf
//         --------------------------------------------------------------------
//         ndio_sbd_mac   1 ~ 4            1 ~ 16             1 ~ 16
// 
// ****************************************************************************

section dio_sbd_mac
 
// ****************************************************************************
// ****                 5V Schottky Diode                                 *****
// ****************************************************************************
subckt ndio_sbd_mac ( n1 n2 ) 
parameters l=1e-006 w=16e-006 nf=16 multi=1 factor=1 lum=l * factor * 1e6 wum=w 
+ * factor * 1e6 a1_eff=multi * (l * w * nf) p1_eff=multi * ((l + w) * 2 * nf) is=( 
+ - 1.3040411) * lum + ( - 1.1959868) * wum + ( - 0.0023183) * nf + ( - 0.0321603) 
+ * lum * wum + ( - 0.0173839) * lum * nf + ( - 0.0055588) * wum * nf + ( - 0.0005590) 
+ * lum * wum * nf + (7.58829237) * sqrt(lum * wum) + (0.02794188) * sqrt(lum * 
+ wum) * nf + ( - 4.0931213) n_S1=( - 0.0002718) * lum + ( - 0.0011858) * wum + 
+ ( - 0.0143185) / lum + ( - 0.0112975) / wum + (0.00171810) / lum / wum + (0.00064363) 
+ * wum * lum + (2.38537767942084e-05) * wum * lum * nf + (1.10770243) cj=(2.1077e-06) 
+ * lum + (7.4349e-07) * wum + (4.7402e-05) / lum + ( - 4.0875e-05) / wum + (2.5706e-04) 
+ / lum / wum + ( - 3.1548e-07) * wum * lum + ( - 4.9821e-09) * wum * lum * nf + 
+ ( - 3.1724e-06) * nf + (1.7355e-07) * wum * nf + (2.0660e-07) * lum * nf + (1.7931e-03) 
+ mj=(4.8284e-03) * lum + (4.4514e-05) * wum + ( - 3.7947e-02) / lum + ( - 1.2612e-02) 
+ / wum + ( - 3.0442e-02) / lum / wum + ( - 9.9425e-05) * wum * lum + (3.6390e-05) 
+ * wum * lum * nf + (1.0204e-03) * nf + ( - 8.3777e-05) * wum * nf + ( - 3.4225e-04) 
+ * lum * nf + (3.7525e-01) 
 
 
 
 
 
// =====================
// --- Schottky diode
d1 ( n1 n2 ) ndio_sbd area=a1_eff pj=p1_eff
 
// -- Schottky diode ---
model ndio_sbd diode 
+ level=1                   n=n_S1*n_d_sbd            is=is*is_d_sbd
+ isw=2.71e-13*pow(2,x_jsw_sbd)                       rs=1.000e-10*rs_d_sbd
+ bv=7.8                    ibv=10*is*is_d_sbd        fc=0
+ cj=cj*cj_d_sbd            vj=0.6                    mj=mj
+ cjsw=1.500e-10*cjsw_d_sbd vjsw=0.4                  mjsw=0.03
+ cta=7.000e-04             ctp=3.000e-04             pta=9.000e-04
+ ptp=1.500e-03             tlev=1                    eg=0.650
+ xti=2                     tlevc=1                   trs=2.500e-03
+ tbv1=-1*-0.0005           tnom=25                   jtun=is*is_d_sbd
+ jtunsw=2.71e-13*pow(2,x_jsw_sbd)                    ntun=32.5
+ xtitun=-5                 ns=n_S1*n_d_sbd           nz=n_S1*n_d_sbd
+ imax=1e40                 minr=1e-10                allow_scaling=yes
 
ends ndio_sbd_mac
 
endsection dio_sbd_mac
endlibrary tsmclib
