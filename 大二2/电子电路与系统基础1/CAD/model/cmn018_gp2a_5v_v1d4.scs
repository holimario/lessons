+ puc1=1.7015614e-023       prt=0                     at=355080.19
+ lat=-0.16339009           wat=0                     pat=-1e-15
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     12: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-(dxln_na+dlmisn_na)
+ wmin=5.3e-007-(dxwn_na+dwmisn_na)                   wmax=1.23e-006-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.0021752367+(dvth0n_na+vthmisn_na)           lvth0=-1.003713e-008+dlvth0n_na
+ wvth0=1.222165e-008+dwvth0n_na                      pvth0=4.2622712e-015
+ k1=0.042                  k2=-0.0067757214+dk2n_na  lk2=4.7342822e-009
+ wk2=8.8875357e-009+dwk2n_na                         pk2=-3.4307544e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.076380358         lvoff=2.0888574e-009+dlvoffn_na
+ wvoff=-7.7446123e-009     pvoff=1.8170735e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.053901714+du0n_na    wu0=3.8486905e-009        ua=6.8485116e-010
+ lua=1.6820943e-016        wua=-8.0018125e-020       pua=9.9976432e-023
+ ub=1.8103891e-018         lub=-1.2670354e-025       wub=4.9619814e-025
+ pub=-2.5386686e-031       uc=-6.3310217e-011        luc=1.5392919e-017
+ wuc=-3.3329606e-017       puc=1.6053059e-023        vsat=230760.85
+ lvsat=0.0038947956        wvsat=-0.0023079146       pvsat=2.6919608e-009
+ a0=9.5685352              la0=-3.9963991e-006       wa0=-4.1941282e-006
+ pa0=1.9561582e-012        ags=-1.8796554            lags=3.0412731e-006
+ wags=1.2189975e-006       pags=5.0848148e-013       a1=0
+ a2=0.2021                 b0=0                      b1=0
+ keta=-0.0043770989        lketa=-9.6730187e-009     wketa=-1.5195561e-008
+ pketa=8.0355029e-015      dwg=0                     dwb=0
+ pclm=0.7724               pdiblc1=0                 pdiblc2=0.038843752
+ lpdiblc2=5.9582269e-009   wpdiblc2=-2.0297315e-008  ppdiblc2=2.7353312e-015
+ pdiblcb=0                 drout=0.5                 pvag=0.309
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=65.92                 rdw=65.92                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=0
+ bgidl=0                   cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=1.257                moin=24.64
+ noff=3.328                voffcv=-0.0428            kt1=-0.39756
+ lkt1=1.4220995e-08        wkt1=8.4480933e-09        pkt1=-4.8148423e-15
+ kt1l=0                    kt2=-0.014083108          pkt2=-7.085351e-16
+ wkt2=-3.547201e-10        lkt2=-1.660035e-10        ute=-1.782
+ ua1=-3.531041e-10         lua1=7.1240486e-16        wua1=6.4297454e-16
+ pua1=-2.8345791e-22       ub1=4.6927237e-19         lub1=-1.8883266e-24
+ wub1=-1.8712397e-24       pub1=7.3510211e-31        uc1=-7.4575817e-011
+ luc1=3.201751e-017        wuc1=2.705887e-017        puc1=-2.1236579e-023
+ prt=0                     at=272577.46              pat=2.1256053e-09
+ wat=-0.0018223576         lat=-0.067158573          jss=4.98e-07
+ jsd=4.98e-07              jsws=4.12e-13             jswd=4.12e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn_na
+ cjd=cjn_na                mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn_na
+ cjswd=cjswn_na            mjsws=0.202               mjswd=0.202
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgn_na
+ cjswgd=cjswgn_na          mjswgs=0.583              mjswgd=0.583
+ tpb=0.00149               tcj=9.05e-04              tpbsw=0.000894
+ tcjsw=0.000809            tpbswg=0.00115            tcjswg=0.000928
+ xtis=3                    xtid=3                    dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rshg=8.23                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lu0=0+dlu0n_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ pu0=0+dpu0n_na            fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     13: type=n 
+ lmin=1e-005-(dxln_na+dlmisn_na)                     lmax=900.01e-6
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.019665613+(dvth0n_na+vthmisn_na)            wvth0=3.9394153e-009+dwvth0n_na
+ k1=0.042                  k2=0.0065262484+dk2n_na   wk2=2.0976371e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.061093484         wvoff=-7.7569931e-009
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.050007742+du0n_na    wu0=3.2490023e-009        ua=1.4384007e-009
+ wua=-1.4661123e-016       ub=1.0413548e-019         wub=6.8635174e-025
+ uc=-6.3913576e-011        wuc=-1.7133208e-017       vsat=234100
+ a0=5.7009523              wa0=-8.5936111e-007       ags=0.78905936
+ wags=2.3474042e-007       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.047126916
+ wketa=5.4908139e-009      dwg=0                     dwb=0
+ pclm=0.75172671           wpclm=1.1209058e-008      pdiblc1=0
+ pdiblc2=-0.0093686673     wpdiblc2=6.9696379e-009   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.3532254            pkt1=0
+ lkt1=0                    wkt1=-1.1708592e-08       kt1l=0
+ kt2=-0.015                pkt2=0                    lkt2=0
+ wkt2=9.9999998e-17        ute=-1.782                ua1=6.5834584e-10
+ pua1=0                    lua1=0                    wua1=7.6940444e-17
+ ub1=-1.1078328e-018       wub1=-3.8098614e-025      uc1=-9.0507994e-011
+ wuc1=2.7385435e-017       prt=0                     at=300000
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lvth0=0+dlvth0n_na        lu0=0+dlu0n_na            pu0=0+dpu0n_na
+ lvoff=0+dlvoffn_na        saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 pvoff=0+dpvoffn_na        fnoimod=1
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=4.10e7                 ef=0.93                   minr=1e-3
 
 
 
     14: type=n 
+ lmin=3e-006-(dxln_na+dlmisn_na)                     lmax=1e-005-(dxln_na+dlmisn_na)
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.035827019+(dvth0n_na+vthmisn_na)            lvth0=1.6107111e-007+dlvth0n_na
+ wvth0=6.245616e-009+dwvth0n_na                      pvth0=-2.2984527e-014
+ k1=0.042                  k2=0.0030951675+dk2n_na   lk2=3.4195539e-008
+ wk2=3.3823974e-009+dwk2n_na                         pk2=-1.280444e-014
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.052420315         lvoff=-8.6440309e-008+dlvoffn_na
+ wvoff=-1.1030421e-008     pvoff=3.2624307e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.05138213+du0n_na     lu0=-1.3697709e-008+dlu0n_na
+ wu0=2.0442706e-009        pu0=1.2006843e-014+dpu0n_na
+ ua=2.0784924e-009         lua=-6.3794127e-015       wua=-3.6224099e-016
+ pua=2.1490533e-021        ub=-9.747155e-019         lub=1.0752265e-023
+ wub=9.8799934e-025        pub=-3.0063419e-030       uc=-7.7461161e-011
+ luc=1.350207e-016         wuc=-1.438401e-017        puc=-2.7399615e-023
+ vsat=232735.1             lvsat=0.013603157         wvsat=0.00074004946
+ pvsat=-7.3756319e-009     a0=5.5422428              la0=1.5817625e-006
+ wa0=-7.7330885e-007       pa0=-8.5763162e-013       ags=1.0058056
+ lags=-2.1601807e-006      wags=9.5852065e-008       pags=1.3842174e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.040026307         lketa=-7.0767536e-008
+ wketa=3.8420526e-009      pketa=1.6432222e-014      dwg=0
+ dwb=0                     pclm=0.74296595           lpclm=8.7313289e-008
+ wpclm=1.5959143e-008      ppclm=-4.7341266e-014     pdiblc1=0
+ pdiblc2=-0.019522161      lpdiblc2=1.0119382e-007   wpdiblc2=9.5877436e-009
+ ppdiblc2=-2.6093099e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.33400354           lkt1=-1.9157284e-07       wkt1=-1.9005824e-08
+ pkt1=7.2727171e-14        kt1l=0                    kt2=-0.015
+ lkt2=-5e-16               wkt2=-6.6e-17             pkt2=1.5e-22
+ ute=-1.782                ua1=3.14449e-11           lua1=6.2479485e-15
+ wua1=3.2848842e-16        pua1=-2.5070287e-21       ub1=3.102742e-019
+ lub1=-1.4133428e-023      wub1=-8.3153858e-025      pub1=4.4903876e-030
+ uc1=-9.9215112e-011       luc1=8.6778654e-017       wuc1=3.2106434e-017
+ puc1=-4.7051386e-023      prt=0                     at=284129.06
+ lat=0.15817624            wat=0.008605226           pat=-8.576316e-08
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     15: type=n 
+ lmin=1.2e-006-(dxln_na+dlmisn_na)                   lmax=3e-006-(dxln_na+dlmisn_na)
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.023161032+(dvth0n_na+vthmisn_na)             lvth0=-1.3911287e-008+dlvth0n_na
+ wvth0=-5.0291428e-009+dwvth0n_na                    pvth0=1.0460962e-014
+ k1=0.042                  k2=0.017369029+dk2n_na    lk2=-8.1464998e-009
+ wk2=-7.8934462e-010+dwk2n_na                        pk2=-4.2936785e-016
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.084779302         lvoff=9.5495215e-009+dlvoffn_na
+ wvoff=3.2518727e-009      pvoff=-9.7427467e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.042879011+du0n_na    lu0=1.1525977e-008+dlu0n_na
+ wu0=7.1445597e-009        pu0=-3.1226752e-015+dpu0n_na
+ ua=-8.5560538e-010        lua=2.3243066e-015        wua=6.4968384e-016
+ pua=-8.5272454e-022       ub=3.4651675e-018         lub=-2.418222e-024
+ wub=-3.3132034e-025       pub=9.0729329e-031        uc=-6.0078563e-012
+ luc=-7.6938667e-017       wuc=-3.392692e-017        puc=3.0572552e-023
+ vsat=239407.95            lvsat=-0.0061912134       wvsat=-0.0028779701
+ pvsat=3.3568759e-009      a0=9.0403821              la0=-8.7951318e-006
+ wa0=-1.7508767e-006       pa0=2.0422296e-012        ags=-1.5260194
+ lags=5.3502349e-006       wags=6.7433082e-007       pags=-3.3178424e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.091514384         lketa=8.19669e-008
+ wketa=1.7831886e-008      pketa=-2.5067276e-014     dwg=0
+ dwb=0                     pclm=0.8343338            lpclm=-1.8372066e-007
+ wpclm=-3.3580504e-008     ppclm=9.961334e-014       pdiblc1=0
+ pdiblc2=0.018553398       lpdiblc2=-1.1753668e-008  wpdiblc2=4.7336555e-010
+ ppdiblc2=9.4382859e-016   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.40866673           lkt1=2.9908344e-08        wkt1=7.105931e-09
+ pkt1=-4.730852e-15        kt1l=0                    kt2=-0.015322747
+ pkt2=-1.5613377e-15       wkt2=5.2634018e-10        lkt2=9.573978e-10
+ ute=-1.782                ua1=2.6748922e-09         lua1=-1.5935844e-15
+ wua1=-7.413548e-16        pua1=6.6655845e-22        ub1=-5.011895e-18
+ lub1=1.6542762e-24        wub1=1.0697799e-24        pub1=-1.149691e-30
+ uc1=-9.980334e-011        luc1=8.8523574e-017       wuc1=2.919298e-017
+ puc1=-3.8408905e-023      prt=0                     at=419227.4
+ lat=-0.24258003           wat=-0.03478062           pat=4.2936785e-08
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     16: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-(dxln_na+dlmisn_na)
+ wmin=2.2e-007             wmax=5.3e-007-(dxwn_na+dwmisn_na)
+ version=4.5               ud=0                      rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=(toxn_na+toxmisn_na) dtox=5.489e-010
+ epsrox=3.9                wint=-6.1e-009            lint=9.298e-009
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+(dxln_na+dlmisn_na)
+ xw=0+(dxwn_na+dwmisn_na)  dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.020835647+(dvth0n_na+vthmisn_na)             lvth0=-1.1198948e-008+dlvth0n_na
+ wvth0=-2.5485058e-010+dwvth0n_na                    pvth0=4.8922085e-015
+ k1=0.042                  k2=0.011276519+dk2n_na    lk2=-1.0401727e-009
+ wk2=-9.0038917e-010+dwk2n_na                        pk2=-2.9984504e-016
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.094701242         lvoff=2.1122512e-008+dlvoffn_na
+ wvoff=2.1889711e-009      pvoff=-8.502974e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.052760645+du0n_na    wu0=4.4673782e-009        ua=1.0203154e-009
+ lua=1.3622514e-016        wua=-1.8196871e-016       pua=1.1731832e-022
+ ub=1.3457674e-018         lub=5.3854776e-026        wub=7.4811601e-025
+ pub=-3.5176557e-031       uc=-1.1618645e-010        luc=5.1574084e-017
+ wuc=-4.6601134e-018       puc=-3.5643684e-024       vsat=247565.19
+ lvsat=-0.015705853        wvsat=-0.011419227        pvsat=1.3319432e-008
+ a0=1.8331457              la0=-3.8858249e-007       ags=-2.7302665
+ lags=6.7548736e-006       wags=1.6801988e-006       pags=-1.5050327e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.010493704         lketa=-1.2535946e-008
+ wketa=-1.1879138e-008     pketa=9.5877818e-015      dwg=0
+ dwb=0                     pclm=0.67682348           wpclm=5.1821587e-008
+ pdiblc1=0                 pdiblc2=0.0074486026      lpdiblc2=1.1990091e-009
+ wpdiblc2=-3.2748645e-009  ppdiblc2=5.3157791e-015   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.38761784           lkt1=5.356835e-09
+ wkt1=3.057456e-09         pkt1=-8.6965e-18          kt1l=0
+ kt2=-0.013239267          pkt2=0                    wkt2=-8.122506e-10
+ lkt2=-1.4727816e-09       ute=-1.782                ua1=8.1267718e-010
+ lua1=5.7851072e-016       wua1=1.0887941e-017       pua1=-2.108605e-022
+ ub1=-2.3134319e-18        lub1=-1.4932219e-24       wub1=-3.6245735e-25
+ pub1=5.2087623e-31        uc1=-1.3187543e-011       luc1=-1.2505437e-017
+ wuc1=-6.2258524e-018      puc1=2.9037625e-024       prt=0
+ at=263521.02              lat=-0.060963473          wat=0.0030880447
+ pat=-1.2333784e-09        jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 lu0=0+dlu0n_na            pu0=0+dpu0n_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
     } 
ends nanch_mac
// 
 
// *********************************************************************************************
//                                                                            
//                   *
//                              1.8V CORE NATIVE NMOS DEVICE MODELS           
//                     *
//                                                                            
//                   *
// *********************************************************************************************
 
model nanch bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_na       lmax=900.01e-6            wmin=1.003e-005-dxwn_na
+ wmax=900.01e-6            version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.033+dvth0n_na     k1=0.042                  k2=0.0030793+dk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.075               nfactor=1.1
+ eta0=0.21                 etab=-0.0416              u0=0.056+du0n_na
+ ua=9.221e-010             ub=1.992e-018             uc=-2.5346e-011
+ vsat=234100               a0=4.116                  ags=1.8
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.02348             dwg=0
+ dwb=0                     pclm=0.7724               pdiblc1=0
+ pdiblc2=0.03803           pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.37195              pkt1=0                    wkt1=0
+ lkt1=0                    kt1l=0                    kt2=-0.015
+ pkt2=0                    wkt2=0                    lkt2=0
+ ute=-1.9                  pute=0                    wute=0
+ lute=0                    ua1=1.0103e-09            pua1=0
+ wua1=0                    lua1=0                    ub1=-2.2188e-18
+ pub1=0                    wub1=0                    lub1=0
+ uc1=-4e-011               prt=0                     at=300000
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lvth0=0+dlvth0n_na        wvth0=0+dwvth0n_na        lu0=0+dlu0n_na
+ pu0=0+dpu0n_na            wk2=0+dwk2n_na            lvoff=0+dlvoffn_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ pvoff=0+dpvoffn_na        fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     2: type=n 
+ lmin=3e-006-dxln_na       lmax=1e-005-dxln_na       wmin=1.003e-005-dxwn_na
+ wmax=900.01e-6            version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.030245482+dvth0n_na                         lvth0=-2.7452639e-008+dlvth0n_na
+ k1=0.042                  k2=0.0035260828+dk2n_na   lk2=-4.4528181e-009
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.083390686         lvoff=8.3624963e-008+dlvoffn_na
+ nfactor=1.1423772         lnfactor=-4.223483e-007   eta0=0.21
+ etab=-0.0416              u0=0.055576228+du0n_na    lu0=4.223483e-009+dlu0n_na
+ ua=1.0819044e-009         lua=-1.5926754e-015       ub=1.6580677e-018
+ lub=3.3281046e-024        uc=-2.0817996e-011        luc=-4.5127915e-017
+ vsat=234100               a0=4.116                  ags=1.8050853
+ lags=-5.0681796e-008      a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.020717007
+ lketa=-2.7537109e-008     dwg=0                     dwb=0
+ pclm=0.67594949           lpclm=9.6126472e-007      pdiblc1=0
+ pdiblc2=0.041432889       lpdiblc2=-3.3914568e-008  pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.36819962           pkt1=0
+ wkt1=0                    lkt1=-3.737782e-08        kt1l=0
+ kt2=-0.015                pkt2=0                    wkt2=0
+ lkt2=0                    ute=-1.9500051            pute=0
+ wute=0                    lute=4.98371e-07          ua1=9.277492e-10
+ pua1=0                    wua1=0                    lua1=8.227345e-16
+ ub1=-2.2466418e-18        pub1=0                    wub1=0
+ lub1=2.774828e-25         uc1=-4.3559685e-011       luc1=3.5477257e-017
+ prt=0                     at=300000                 jss=4.98e-07
+ jsd=4.98e-07              jsws=4.12e-13             jswd=4.12e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn_na
+ cjd=cjn_na                mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn_na
+ cjswd=cjswn_na            mjsws=0.202               mjswd=0.202
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgn_na
+ cjswgd=cjswgn_na          mjswgs=0.583              mjswgd=0.583
+ tpb=0.00149               tcj=9.05e-04              tpbsw=0.000894
+ tcjsw=0.000809            tpbswg=0.00115            tcjswg=0.000928
+ xtis=3                    xtid=3                    dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rshg=8.23                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wvth0=0+dwvth0n_na
+ pu0=0+dpu0n_na            wk2=0+dwk2n_na            saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.8                 wlod=5.00e-07
+ tku0=0.03                 ku0=-2.80e-08             llodku0=1
+ wlodku0=1                 lku0=2.00e-07             wku0=3.00e-06
+ pku0=-5.00e-14            kvth0=1.30e-08            stk2=2.50e-09
+ steta0=-1.10e-10          lkvth0=-1.00e-08          wkvth0=1.00e-06
+ pkvth0=-5.00e-14          llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 pvoff=0+dpvoffn_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     3: type=n 
+ lmin=1.2e-006-dxln_na     lmax=3e-006-dxln_na       wmin=1.003e-005-dxwn_na
+ wmax=900.01e-6            version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.039824001+dvth0n_na                         lvth0=9.6111819e-010+dlvth0n_na
+ k1=0.042                  k2=0.00070488987+dk2n_na  lk2=3.91598e-009
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.052089589         lvoff=-9.2267346e-009+dlvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056351998+du0n_na    lu0=1.9222364e-009+dlu0n_na
+ ua=3.1366321e-010         lua=6.8623839e-016        ub=3.1882414e-018
+ lub=-1.2110089e-024       uc=-3.9344883e-011        luc=9.8303169e-018
+ vsat=234100               a0=4.116                  ags=1.7672639
+ lags=6.1511564e-008       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.038119468
+ lketa=2.4085622e-008      dwg=0                     dwb=0
+ pclm=1.1474853            lpclm=-4.37501e-007       pdiblc1=0
+ pdiblc2=0.033240011       lpdiblc2=-9.6111819e-009  pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.39022843           pkt1=0
+ wkt1=0                    lkt1=2.7968539e-08        kt1l=0
+ kt2=-0.014351997          pkt2=0                    wkt2=0
+ lkt2=-1.9222364e-09       ute=-1.782                ua1=1.2842211e-09
+ pua1=0                    wua1=0                    lua1=-2.3470507e-16
+ ub1=-1.6035293e-18        pub1=0                    wub1=0
+ lub1=-1.6302487e-24       uc1=-3.9116826e-011       luc1=2.2297942e-017
+ prt=0                     at=364800.22              lat=-0.19222364
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvth0n_na        pu0=0+dpu0n_na            wk2=0+dwk2n_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ pvoff=0+dpvoffn_na        fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     4: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-dxln_na     wmin=1.003e-005-dxwn_na
+ wmax=900.01e-6            version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.049327517+dvth0n_na                         lvth0=1.2046057e-008+dlvth0n_na
+ k1=0.042                  k2=0.0048179744+dk2n_na   lk2=-8.8153825e-010
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.037346091         lvoff=-2.642361e-008+dlvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056840653+du0n_na    lu0=1.3522671e-009+dlu0n_na
+ ua=9.2378773e-010         lua=-2.5413295e-017       ub=1.8634947e-018
+ lub=3.3418095e-025        uc=-1.6488459e-011        luc=-1.6829508e-017
+ vsat=234100               a0=4.116                  ags=1.7467079
+ lags=8.5488149e-008       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.023869196
+ lketa=7.464048e-009       dwg=0                     dwb=0
+ pclm=0.75401036           lpclm=2.1449754e-008      pdiblc1=0
+ pdiblc2=0.0016798         lpdiblc2=2.7200775e-008   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.38701022           pkt1=0
+ wkt1=0                    lkt1=2.4214805e-08        kt1l=0
+ kt2=-0.015368666          pkt2=0                    wkt2=0
+ lkt2=-7.3639077e-10       ute=-1.9818874            lute=2.331495e-007
+ ua1=-1.9397447e-11        pua1=0                    wua1=0
+ lua1=1.2858408e-15        ub1=-1.847338e-18         pub1=0
+ wub1=0                    lub1=-1.3458693e-24       uc1=-3.16601e-011
+ luc1=1.3600387e-017       prt=0                     at=256801.14
+ pat=0                     wat=0                     lat=-0.066253078
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvth0=0+dwvth0n_na        pu0=0+dpu0n_na            saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.8                 wlod=5.00e-07
+ tku0=0.03                 ku0=-2.80e-08             llodku0=1
+ wlodku0=1                 lku0=2.00e-07             wku0=3.00e-06
+ pku0=-5.00e-14            kvth0=1.30e-08            stk2=2.50e-09
+ steta0=-1.10e-10          lkvth0=-1.00e-08          wkvth0=1.00e-06
+ pkvth0=-5.00e-14          llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 wk2=0+dwk2n_na
+ pvoff=0+dpvoffn_na        fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     5: type=n 
+ lmin=1e-005-dxln_na       lmax=900.01e-6            wmin=1.23e-006-dxwn_na
+ wmax=1.003e-005-dxwn_na   version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.035258546+dvth0n_na                         wvth0=2.2680765e-008+dwvth0n_na
+ k1=0.042                  k2=0.003231653+dk2n_na    wk2=-1.5299594e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.075705796         wvoff=7.0877391e-009
+ nfactor=1.1141159         wnfactor=-1.4175478e-007  eta0=0.21
+ etab=-0.0416              u0=0.056282318+du0n_na    wu0=-2.8350957e-009
+ ua=8.8033103e-010         wua=4.194524e-016         ub=2.1204548e-018
+ wub=-1.2899685e-024       uc=-1.7209025e-011        wuc=-8.1713127e-017
+ vsat=234100               a0=4.116                  ags=1.8230089
+ wags=-2.310603e-007       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.019582598
+ wketa=-3.9138495e-008     dwg=0                     dwb=0
+ pclm=0.7724               pdiblc1=0                 pdiblc2=0.037751917
+ wpdiblc2=2.7925692e-009   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.37123008           pkt1=0                    wkt1=-7.229494e-09
+ lkt1=0                    kt1l=0                    kt2=-0.015
+ pkt2=0                    wkt2=0                    lkt2=0
+ ute=-1.9166567            pute=0                    lute=0
+ wute=1.6727065e-07        ua1=9.6730293e-10         pua1=0
+ lua1=0                    wua1=4.3178514e-16        ub1=-2.1440139e-18
+ pub1=0                    lub1=0                    wub1=-7.5101684e-25
+ uc1=-4.3077268e-011       wuc1=3.0902543e-017       prt=0
+ at=300000                 jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvth0n_na        lu0=0+dlu0n_na
+ pu0=0+dpu0n_na            lvoff=0+dlvoffn_na        saref=1.00e-05
+ sbref=1.00e-05            kvsat=0.8                 wlod=5.00e-07
+ tku0=0.03                 ku0=-2.80e-08             llodku0=1
+ wlodku0=1                 lku0=2.00e-07             wku0=3.00e-06
+ pku0=-5.00e-14            kvth0=1.30e-08            stk2=2.50e-09
+ steta0=-1.10e-10          lkvth0=-1.00e-08          wkvth0=1.00e-06
+ pkvth0=-5.00e-14          llodvth=1                 wlodvth=1
+ lodk2=1                   lodeta0=2                 pvoff=0+dpvoffn_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     6: type=n 
+ lmin=3e-006-dxln_na       lmax=1e-005-dxln_na       wmin=1.23e-006-dxwn_na
+ wmax=1.003e-005-dxwn_na   version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.031756287+dvth0n_na                         lvth0=-3.4904927e-008+dlvth0n_na
+ wvth0=1.5171802e-008+dwvth0n_na                     pvth0=7.4837363e-014
+ k1=0.042                  k2=0.0037415033+dk2n_na   lk2=-5.0813738e-009
+ wk2=-2.1632954e-009+dwk2n_na                        pk2=6.3120826e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.084981806         lvoff=9.2448471e-008+dlvoffn_na
+ wvoff=1.5978352e-008      pvoff=-8.8607438e-014+dpvoffn_na
+ nfactor=1.162475          lnfactor=-4.819666e-007   wnfactor=-2.0182649e-007
+ pnfactor=5.9869891e-013   eta0=0.21                 etab=-0.0416
+ u0=0.055978185+du0n_na    lu0=3.0311169e-009+dlu0n_na
+ wu0=-4.0365298e-009       pu0=1.1973978e-014+dpu0n_na
+ ua=1.0449928e-009         lua=-1.6410855e-015       wua=3.7067417e-016
+ pua=4.8614351e-022        ub=1.7962132e-018         lub=3.2315229e-024
+ wub=-1.3872847e-024       pub=9.6989223e-031        uc=-1.0698671e-011
+ luc=-6.4884824e-017       wuc=-1.0162029e-016       puc=1.9840283e-022
+ vsat=234100               a0=4.116                  ags=1.8331788
+ lags=-1.0135735e-007      wags=-2.8212125e-007      pags=5.0889407e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.014766607         lketa=-4.799811e-008
+ wketa=-5.9755105e-008     pketa=2.0547347e-013      dwg=0
+ dwb=0                     pclm=0.66233463           lpclm=1.096956e-006
+ wpclm=1.3672321e-007      ppclm=-1.3626387e-012     pdiblc1=0
+ pdiblc2=0.041699759       lpdiblc2=-3.9345795e-008  wpdiblc2=-2.6799634e-009
+ ppdiblc2=5.454147e-014    pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.36719019           lkt1=-4.0263347e-08       wkt1=-1.0136964e-08
+ pkt1=2.897702e-14         kt1l=0                    kt2=-0.015
+ pkt2=0                    wkt2=9.9999996e-19        lkt2=0
+ ute=-1.9737205            lute=5.6872068e-07        wute=2.381553e-07
+ pute=-7.0646463e-13       ua1=8.6187728e-10         lua1=1.0507148e-15
+ wua1=6.6149924e-16        pua1=-2.2894245e-21       ub1=-2.1596765e-18
+ lub1=1.560999e-25         wub1=-8.7332285e-25       pub1=1.218951e-30
+ uc1=-4.8443495e-011       luc1=5.3481984e-017       wuc1=4.9044198e-017
+ puc1=-1.8080707e-022      prt=0                     at=300000
+ lat=0                     wat=0                     pat=0
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     7: type=n 
+ lmin=1.2e-006-dxln_na     lmax=3e-006-dxln_na       wmin=1.23e-006-dxwn_na
+ wmax=1.003e-005-dxwn_na   version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.042703643+dvth0n_na                         lvth0=-2.4306461e-009+dlvth0n_na
+ wvth0=2.8917936e-008+dwvth0n_na                     pvth0=3.4060775e-014
+ k1=0.042                  k2=0.0005284763+dk2n_na   lk2=4.4497623e-009
+ wk2=1.7715804e-009+dwk2n_na                         pk2=-5.3603485e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.051599906         lvoff=-6.5757317e-009+dlvoffn_na
+ wvoff=-4.9174993e-009     pvoff=-2.6621902e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.056260526+du0n_na    lu0=2.1935775e-009+dlu0n_na
+ wu0=9.1857414e-010        pu0=-2.724862e-015+dpu0n_na
+ ua=2.2557236e-010         lua=7.896465e-016         wua=8.8462589e-016
+ pua=-1.0384449e-021       ub=3.3417594e-018         lub=-1.3531917e-024
+ wub=-1.5416586e-024       pub=1.4278277e-030        uc=-3.6841016e-011
+ luc=1.2663932e-017        wuc=-2.514434e-017        puc=-2.8455734e-023
+ vsat=234100               a0=4.116                  ags=1.8073622
+ lags=-2.4774918e-008      wags=-4.0267531e-007      pags=8.6650612e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.039853025         lketa=2.6418342e-008
+ wketa=1.7408728e-008      pketa=-2.3425639e-014     dwg=0
+ dwb=0                     pclm=1.200432             lpclm=-4.9925825e-007
+ wpclm=-5.3170136e-007     ppclm=6.2017859e-013      pdiblc1=0
+ pdiblc2=0.031074087       lpdiblc2=-7.8257572e-009  wpdiblc2=2.1750648e-008
+ ppdiblc2=-1.7929592e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.39159857           lkt1=3.2141767e-08        wkt1=1.3759108e-08
+ pkt1=-4.1908378e-14       kt1l=0                    kt2=-0.014260527
+ pkt2=2.724862e-15         wkt2=-9.1857412e-10       lkt2=-2.1935776e-09
+ ute=-1.782                lute=0                    wute=-1e-14
+ pute=0                    ua1=1.2562768e-09         lua1=-1.1923313e-16
+ wua1=2.8062324e-16        pua1=-1.1595923e-21       ub1=-1.4496658e-18
+ lub1=-1.9500785e-24       wub1=-1.5451275e-24       pub1=3.2117949e-30
+ uc1=-3.8992158e-011       luc1=2.5445499e-017       wuc1=-1.2519417e-018
+ puc1=-3.1608399e-023      prt=0                     at=366172.29
+ lat=-0.19629376           wat=-0.013778612          pat=4.087293e-08
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     8: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-dxln_na     wmin=1.23e-006-dxwn_na
+ wmax=1.003e-005-dxwn_na   version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.057372314+dvth0n_na                         lvth0=1.4678951e-008+dlvth0n_na
+ wvth0=8.078746e-008+dwvth0n_na                      pvth0=-2.6440045e-014
+ k1=0.042                  k2=0.0054445827+dk2n_na   lk2=-1.2844039e-009
+ wk2=-6.292526e-009+dwk2n_na                         pk2=4.0456574e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.03095598          lvoff=-3.0654889e-008+dlvoffn_na
+ wvoff=-6.4170775e-008     pvoff=4.2491355e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.05681816+du0n_na     lu0=1.5431519e-009+dlu0n_na
+ wu0=2.2588211e-010        pu0=-1.9169033e-015+dpu0n_na
+ ua=9.5752489e-010         lua=-6.4105862e-017       wua=-3.3879533e-016
+ pua=3.8855849e-022        ub=1.8146049e-018         lub=4.2808749e-025
+ wub=4.9096126e-025        pub=-9.4302827e-031       uc=-6.0916871e-012
+ luc=-2.3202208e-017       wuc=-1.0440646e-016       puc=6.3995925e-023
+ vsat=234833.61            lvsat=-0.00085569044      wvsat=-0.0073670997
+ pvsat=8.5930146e-009      a0=3.8229306              la0=3.4183736e-007
+ wa0=2.9430619e-006        pa0=-3.4327992e-012       ags=2.1200797
+ lags=-3.8952975e-007      wags=-3.7494734e-006      pags=4.7702248e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.024893915         lketa=8.9699754e-009
+ wketa=1.0290427e-008      pketa=-1.5122824e-014     dwg=0
+ dwb=0                     pclm=0.75141449           lpclm=2.4477581e-008
+ wpclm=2.6068199e-008      ppclm=-3.0406052e-014     pdiblc1=0
+ pdiblc2=-0.0012597167     lpdiblc2=2.988852e-008    wpdiblc2=2.9519214e-008
+ ppdiblc2=-2.6990879e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.38648104           lkt1=2.6172664e-08        wkt1=-5.314191e-09
+ pkt1=-1.9661206e-14       kt1l=0                    kt2=-0.015509825
+ pkt2=0                    wkt2=1.4175478e-09        lkt2=-7.3639081e-10
+ ute=-2.0101034            lute=2.6606067e-007       wute=2.8334999e-007
+ pute=-3.3050056e-013      ua1=-4.5357002e-11        lua1=1.3989976e-15
+ wua1=2.6069111e-16        pua1=-1.1363434e-21       ub1=-1.9617078e-18
+ lub1=-1.3528308e-24       wub1=1.148524e-24         pub1=6.990904e-32
+ uc1=-2.8677028e-011       luc1=1.3413891e-017       wuc1=-2.9956606e-017
+ puc1=1.8728365e-024       prt=0                     at=254781.26
+ lat=-0.066366805          wat=0.020284079           pat=1.142071e-09
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     9: type=n 
+ lmin=1e-005-dxln_na       lmax=900.01e-6            wmin=5.3e-007-dxwn_na
+ wmax=1.23e-006-dxwn_na    version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.020563029+dvth0n_na                         wvth0=4.4259941e-009+dwvth0n_na
+ k1=0.042                  k2=-0.0045025271+dk2n_na  wk2=8.0774392e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.065817314         wvoff=-5.1957322e-009
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.052450857+du0n_na    wu0=1.9243453e-009        ua=1.2567286e-009
+ wua=-4.8108631e-017       ub=8.5892343e-019         wub=2.7710572e-025
+ uc=-7.3290042e-011        wuc=-1.2049288e-017       vsat=234100
+ a0=4.116                  ags=1.9584471             wags=-3.9930164e-007
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.062003711         wketa=1.3557012e-008
+ dwg=0                     dwb=0                     pclm=0.7724
+ pdiblc1=0                 pdiblc2=0.068282934       wpdiblc2=-3.513306e-008
+ pdiblcb=0                 drout=0.5                 pvag=0.309
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=65.92                 rdw=65.92                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=0
+ bgidl=0                   cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=1.257                moin=24.64
+ noff=3.328                voffcv=-0.0428            kt1=-0.3787773
+ pkt1=0                    lkt1=0                    wkt1=2.145645e-09
+ kt1l=0                    kt2=-0.015                pkt2=0
+ lkt2=0                    wkt2=0                    ute=-1.782
+ ua1=1.7135332e-09         pua1=0                    lua1=0
+ wua1=-4.9518214e-16       ub1=-3.4752255e-018       wub1=9.0261414e-025
+ uc1=-1.3143429e-012       wuc1=-2.0975363e-017      prt=0
+ at=300000                 jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lvth0=0+dlvth0n_na        lu0=0+dlu0n_na
+ pu0=0+dpu0n_na            saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 lvoff=0+dlvoffn_na        pvoff=0+dpvoffn_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     10: type=n 
+ lmin=3e-006-dxln_na       lmax=1e-005-dxln_na       wmin=5.3e-007-dxwn_na
+ wmax=1.23e-006-dxwn_na    version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.015851519+dvth0n_na                         lvth0=-4.6956804e-008+dlvth0n_na
+ wvth0=-4.5851001e-009+dwvth0n_na                    pvth0=8.9808205e-014
+ k1=0.042                  k2=-0.0036802817+dk2n_na  lk2=-8.19483e-009
+ wk2=7.056046e-009+dwk2n_na                          pk2=1.0179618e-014
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.071619046         lvoff=5.7822402e-008+dlvoffn_na
+ wvoff=-6.2086898e-010     pvoff=-4.5594935e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.0508513+du0n_na      lu0=1.5941838e-008+dlu0n_na
+ wu0=2.3320871e-009        pu0=-4.0637197e-015+dpu0n_na
+ ua=1.2914952e-009         lua=-3.4649804e-016       wua=6.4468885e-017
+ pua=-1.121993e-021        ub=5.4923243e-019         lub=3.0865057e-024
+ wub=1.6171478e-025        pub=1.1500327e-030        uc=-8.3609611e-011
+ luc=1.0284899e-016        wuc=-1.105032e-017        puc=-9.9561133e-024
+ vsat=234100               a0=4.116                  ags=1.9340766
+ lags=2.4288647e-007       wags=-4.0745648e-007      pags=8.1274394e-014
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.086054247         lketa=2.3969736e-007
+ wketa=2.8798402e-008      pketa=-1.5190184e-013     dwg=0
+ dwb=0                     pclm=0.7724               pdiblc1=0
+ pdiblc2=0.071595214       lpdiblc2=-3.3011525e-008  wpdiblc2=-3.9816097e-008
+ ppdiblc2=4.667304e-014    pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.38022581           lkt1=1.4436452e-08        wkt1=6.0558897e-09
+ pkt1=-3.8971077e-14       kt1l=0                    kt2=-0.015
+ lkt2=-5.1e-16             wkt2=-1.45e-16            pkt2=2.4e-22
+ ute=-1.782                lute=0                    wute=0
+ pute=0                    ua1=1.9808364e-09         lua1=-2.6640508e-15
+ wua1=-7.2847167e-16       pua1=2.3250572e-21        ub1=-4.1325216e-018
+ lub1=6.5508789e-024       wub1=1.5773453e-024       pub1=-6.7246434e-030
+ uc1=1.5079555e-011        luc1=-1.6338821e-016      wuc1=-2.9864135e-017
+ puc1=8.8589089e-023       prt=0                     at=300000.01
+ lat=0                     wat=0                     pat=0
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
 
     11: type=n 
+ lmin=1.2e-006-dxln_na     lmax=3e-006-dxln_na       wmin=5.3e-007-dxwn_na
+ wmax=1.23e-006-dxwn_na    version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.045224711+dvth0n_na                         lvth0=4.0175949e-008+dlvth0n_na
+ wvth0=3.2049607e-008+dwvth0n_na                     pvth0=-1.8865137e-014
+ k1=0.042                  k2=-0.00885727+dk2n_na    lk2=7.1622088e-009
+ wk2=1.3430555e-008+dwk2n_na                         pk2=-8.7297497e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.037570625         lvoff=-4.3178971e-008+dlvoffn_na
+ wvoff=-2.2344672e-008     pvoff=1.8846642e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.057731201+du0n_na    lu0=-4.4667282e-009+dlu0n_na
+ wu0=-9.0829738e-010       pu0=5.5485697e-015+dpu0n_na
+ ua=1.3986533e-009         lua=-6.6437218e-016       wua=-5.7257519e-016
+ pua=7.677371e-022         ub=1.5171163e-018         lub=2.1537093e-025
+ wub=7.2491301e-025        pub=-5.2064079e-031       uc=-4.8176957e-011
+ luc=-2.2585767e-018       wuc=-1.1062834e-017       puc=-9.9189931e-024
+ vsat=234100               a0=2.8029668              la0=3.8949869e-006
+ wa0=1.6310498e-006        pa0=-4.8383528e-012       ags=2.8507242
+ lags=-2.4762606e-006      wags=-1.6987395e-006      pags=3.9117416e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.000442124         lketa=-1.4262789e-008
+ wketa=-3.1547494e-008     pketa=2.7108462e-014      dwg=0
+ dwb=0                     pclm=0.7724               pdiblc1=0
+ pdiblc2=0.071168372       lpdiblc2=-3.1745339e-008  wpdiblc2=-2.8054474e-008
+ ppdiblc2=1.1783313e-014   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.36887351           lkt1=-1.9239026e-08       wkt1=-1.4469947e-08
+ pkt1=2.191685e-14         kt1l=0                    kt2=-0.015501924
+ pkt2=-1.8495233e-15       wkt2=6.2349e-10           lkt2=1.4889094e-09
+ ute=-1.782                lute=0                    wute=0
+ pute=0                    ua1=1.6174262e-09         lua1=-1.5860295e-15
+ wua1=-1.6799675e-16       pua1=6.624622e-22         ub1=-2.4260468e-18
+ lub1=1.4887853e-24        wub1=-3.32267e-25         pub1=-1.0599618e-30
+ uc1=-3.5382299e-011       luc1=-1.3697966e-017      wuc1=-5.736108e-018
+ puc1=1.7015614e-023       prt=0                     at=355080.19
+ lat=-0.16339009           wat=0                     pat=-1e-15
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     12: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-dxln_na     wmin=5.3e-007-dxwn_na
+ wmax=1.23e-006-dxwn_na    version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.0021752367+dvth0n_na                        lvth0=-1.003713e-008+dlvth0n_na
+ wvth0=1.222165e-008+dwvth0n_na                      pvth0=4.2622712e-015
+ k1=0.042                  k2=-0.0067757214+dk2n_na  lk2=4.7342822e-009
+ wk2=8.8875357e-009+dwk2n_na                         pk2=-3.4307544e-015
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.076380358         lvoff=2.0888574e-009+dlvoffn_na
+ wvoff=-7.7446123e-009     pvoff=1.8170735e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.053901714+du0n_na    wu0=3.8486905e-009        ua=6.8485116e-010
+ lua=1.6820943e-016        wua=-8.0018125e-020       pua=9.9976432e-023
+ ub=1.8103891e-018         lub=-1.2670354e-025       wub=4.9619814e-025
+ pub=-2.5386686e-031       uc=-6.3310217e-011        luc=1.5392919e-017
+ wuc=-3.3329606e-017       puc=1.6053059e-023        vsat=230760.85
+ lvsat=0.0038947956        wvsat=-0.0023079146       pvsat=2.6919608e-009
+ a0=9.5685352              la0=-3.9963991e-006       wa0=-4.1941282e-006
+ pa0=1.9561582e-012        ags=-1.8796554            lags=3.0412731e-006
+ wags=1.2189975e-006       pags=5.0848148e-013       a1=0
+ a2=0.2021                 b0=0                      b1=0
+ keta=-0.0043770989        lketa=-9.6730187e-009     wketa=-1.5195561e-008
+ pketa=8.0355029e-015      dwg=0                     dwb=0
+ pclm=0.7724               pdiblc1=0                 pdiblc2=0.038843752
+ lpdiblc2=5.9582269e-009   wpdiblc2=-2.0297315e-008  ppdiblc2=2.7353312e-015
+ pdiblcb=0                 drout=0.5                 pvag=0.309
+ delta=0.005               pscbe1=1e+009             pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=200
+ rsw=65.92                 rdw=65.92                 prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=0.14               beta0=10                  agidl=0
+ bgidl=0                   cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.515e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.925e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=1.257                moin=24.64
+ noff=3.328                voffcv=-0.0428            kt1=-0.39756
+ lkt1=1.4220995e-08        wkt1=8.4480933e-09        pkt1=-4.8148423e-15
+ kt1l=0                    kt2=-0.014083108          pkt2=-7.085351e-16
+ wkt2=-3.547201e-10        lkt2=-1.660035e-10        ute=-1.782
+ ua1=-3.531041e-10         lua1=7.1240486e-16        wua1=6.4297454e-16
+ pua1=-2.8345791e-22       ub1=4.6927237e-19         lub1=-1.8883266e-24
+ wub1=-1.8712397e-24       pub1=7.3510211e-31        uc1=-7.4575817e-011
+ luc1=3.201751e-017        wuc1=2.705887e-017        puc1=-2.1236579e-023
+ prt=0                     at=272577.46              pat=2.1256053e-09
+ wat=-0.0018223576         lat=-0.067158573          jss=4.98e-07
+ jsd=4.98e-07              jsws=4.12e-13             jswd=4.12e-13
+ jswgs=1.0e-12             jswgd=1.0e-12             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=11.25
+ bvd=11.25                 xjbvs=1                   xjbvd=1
+ pbs=0.6882682             pbd=0.6882682             cjs=cjn_na
+ cjd=cjn_na                mjs=0.359                 mjd=0.359
+ pbsws=0.32                pbswd=0.32                cjsws=cjswn_na
+ cjswd=cjswn_na            mjsws=0.202               mjswd=0.202
+ pbswgs=0.97               pbswgd=0.97               cjswgs=cjswgn_na
+ cjswgd=cjswgn_na          mjswgs=0.583              mjswgd=0.583
+ tpb=0.00149               tcj=9.05e-04              tpbsw=0.000894
+ tcjsw=0.000809            tpbswg=0.00115            tcjswg=0.000928
+ xtis=3                    xtid=3                    dmcg=2.05e-007
+ dmci=3.15e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rshg=8.23                 gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lu0=0+dlu0n_na
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ pu0=0+dpu0n_na            fnoimod=1                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=4.10e7
+ ef=0.93                   minr=1e-3
 
 
 
     13: type=n 
+ lmin=1e-005-dxln_na       lmax=900.01e-6            wmin=2.2e-007
+ wmax=5.3e-007-dxwn_na     version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.019665613+dvth0n_na                         wvth0=3.9394153e-009+dwvth0n_na
+ k1=0.042                  k2=0.0065262484+dk2n_na   wk2=2.0976371e-009+dwk2n_na
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.061093484         wvoff=-7.7569931e-009
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.050007742+du0n_na    wu0=3.2490023e-009        ua=1.4384007e-009
+ wua=-1.4661123e-016       ub=1.0413548e-019         wub=6.8635174e-025
+ uc=-6.3913576e-011        wuc=-1.7133208e-017       vsat=234100
+ a0=5.7009523              wa0=-8.5936111e-007       ags=0.78905936
+ wags=2.3474042e-007       a1=0                      a2=0.2021
+ b0=0                      b1=0                      keta=-0.047126916
+ wketa=5.4908139e-009      dwg=0                     dwb=0
+ pclm=0.75172671           wpclm=1.1209058e-008      pdiblc1=0
+ pdiblc2=-0.0093686673     wpdiblc2=6.9696379e-009   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.3532254            pkt1=0
+ lkt1=0                    wkt1=-1.1708592e-08       kt1l=0
+ kt2=-0.015                pkt2=0                    lkt2=0
+ wkt2=9.9999998e-17        ute=-1.782                ua1=6.5834584e-10
+ pua1=0                    lua1=0                    wua1=7.6940444e-17
+ ub1=-1.1078328e-018       wub1=-3.8098614e-025      uc1=-9.0507994e-011
+ wuc1=2.7385435e-017       prt=0                     at=300000
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lvth0=0+dlvth0n_na        lu0=0+dlu0n_na            pu0=0+dpu0n_na
+ lvoff=0+dlvoffn_na        saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 pvoff=0+dpvoffn_na        fnoimod=1
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=4.10e7                 ef=0.93                   minr=1e-3
 
 
 
     14: type=n 
+ lmin=3e-006-dxln_na       lmax=1e-005-dxln_na       wmin=2.2e-007
+ wmax=5.3e-007-dxwn_na     version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.035827019+dvth0n_na                         lvth0=1.6107111e-007+dlvth0n_na
+ wvth0=6.245616e-009+dwvth0n_na                      pvth0=-2.2984527e-014
+ k1=0.042                  k2=0.0030951675+dk2n_na   lk2=3.4195539e-008
+ wk2=3.3823974e-009+dwk2n_na                         pk2=-1.280444e-014
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.052420315         lvoff=-8.6440309e-008+dlvoffn_na
+ wvoff=-1.1030421e-008     pvoff=3.2624307e-014+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.05138213+du0n_na     lu0=-1.3697709e-008+dlu0n_na
+ wu0=2.0442706e-009        pu0=1.2006843e-014+dpu0n_na
+ ua=2.0784924e-009         lua=-6.3794127e-015       wua=-3.6224099e-016
+ pua=2.1490533e-021        ub=-9.747155e-019         lub=1.0752265e-023
+ wub=9.8799934e-025        pub=-3.0063419e-030       uc=-7.7461161e-011
+ luc=1.350207e-016         wuc=-1.438401e-017        puc=-2.7399615e-023
+ vsat=232735.1             lvsat=0.013603157         wvsat=0.00074004946
+ pvsat=-7.3756319e-009     a0=5.5422428              la0=1.5817625e-006
+ wa0=-7.7330885e-007       pa0=-8.5763162e-013       ags=1.0058056
+ lags=-2.1601807e-006      wags=9.5852065e-008       pags=1.3842174e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.040026307         lketa=-7.0767536e-008
+ wketa=3.8420526e-009      pketa=1.6432222e-014      dwg=0
+ dwb=0                     pclm=0.74296595           lpclm=8.7313289e-008
+ wpclm=1.5959143e-008      ppclm=-4.7341266e-014     pdiblc1=0
+ pdiblc2=-0.019522161      lpdiblc2=1.0119382e-007   wpdiblc2=9.5877436e-009
+ ppdiblc2=-2.6093099e-014  pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.33400354           lkt1=-1.9157284e-07       wkt1=-1.9005824e-08
+ pkt1=7.2727171e-14        kt1l=0                    kt2=-0.015
+ lkt2=-5e-16               wkt2=-6.6e-17             pkt2=1.5e-22
+ ute=-1.782                ua1=3.14449e-11           lua1=6.2479485e-15
+ wua1=3.2848842e-16        pua1=-2.5070287e-21       ub1=3.102742e-019
+ lub1=-1.4133428e-023      wub1=-8.3153858e-025      pub1=4.4903876e-030
+ uc1=-9.9215112e-011       luc1=8.6778654e-017       wuc1=3.2106434e-017
+ puc1=-4.7051386e-023      prt=0                     at=284129.06
+ lat=0.15817624            wat=0.008605226           pat=-8.576316e-08
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     15: type=n 
+ lmin=1.2e-006-dxln_na     lmax=3e-006-dxln_na       wmin=2.2e-007
+ wmax=5.3e-007-dxwn_na     version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.023161032+dvth0n_na                          lvth0=-1.3911287e-008+dlvth0n_na
+ wvth0=-5.0291428e-009+dwvth0n_na                    pvth0=1.0460962e-014
+ k1=0.042                  k2=0.017369029+dk2n_na    lk2=-8.1464998e-009
+ wk2=-7.8934462e-010+dwk2n_na                        pk2=-4.2936785e-016
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.084779302         lvoff=9.5495215e-009+dlvoffn_na
+ wvoff=3.2518727e-009      pvoff=-9.7427467e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.042879011+du0n_na    lu0=1.1525977e-008+dlu0n_na
+ wu0=7.1445597e-009        pu0=-3.1226752e-015+dpu0n_na
+ ua=-8.5560538e-010        lua=2.3243066e-015        wua=6.4968384e-016
+ pua=-8.5272454e-022       ub=3.4651675e-018         lub=-2.418222e-024
+ wub=-3.3132034e-025       pub=9.0729329e-031        uc=-6.0078563e-012
+ luc=-7.6938667e-017       wuc=-3.392692e-017        puc=3.0572552e-023
+ vsat=239407.95            lvsat=-0.0061912134       wvsat=-0.0028779701
+ pvsat=3.3568759e-009      a0=9.0403821              la0=-8.7951318e-006
+ wa0=-1.7508767e-006       pa0=2.0422296e-012        ags=-1.5260194
+ lags=5.3502349e-006       wags=6.7433082e-007       pags=-3.3178424e-013
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.091514384         lketa=8.19669e-008
+ wketa=1.7831886e-008      pketa=-2.5067276e-014     dwg=0
+ dwb=0                     pclm=0.8343338            lpclm=-1.8372066e-007
+ wpclm=-3.3580504e-008     ppclm=9.961334e-014       pdiblc1=0
+ pdiblc2=0.018553398       lpdiblc2=-1.1753668e-008  wpdiblc2=4.7336555e-010
+ ppdiblc2=9.4382859e-016   pdiblcb=0                 drout=0.5
+ pvag=0.309                delta=0.005               pscbe1=1e+009
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=200                  rsw=65.92                 rdw=65.92
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.14               beta0=10
+ agidl=0                   bgidl=0                   cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.515e-005           aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.925e-020          nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=1.257
+ moin=24.64                noff=3.328                voffcv=-0.0428
+ kt1=-0.40866673           lkt1=2.9908344e-08        wkt1=7.105931e-09
+ pkt1=-4.730852e-15        kt1l=0                    kt2=-0.015322747
+ pkt2=-1.5613377e-15       wkt2=5.2634018e-10        lkt2=9.573978e-10
+ ute=-1.782                ua1=2.6748922e-09         lua1=-1.5935844e-15
+ wua1=-7.413548e-16        pua1=6.6655845e-22        ub1=-5.011895e-18
+ lub1=1.6542762e-24        wub1=1.0697799e-24        pub1=-1.149691e-30
+ uc1=-9.980334e-011        luc1=8.8523574e-017       wuc1=2.919298e-017
+ puc1=-3.8408905e-023      prt=0                     at=419227.4
+ lat=-0.24258003           wat=-0.03478062           pat=4.2936785e-08
+ jss=4.98e-07              jsd=4.98e-07              jsws=4.12e-13
+ jswd=4.12e-13             jswgs=1.0e-12             jswgd=1.0e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=11.25                 bvd=11.25                 xjbvs=1
+ xjbvd=1                   pbs=0.6882682             pbd=0.6882682
+ cjs=cjn_na                cjd=cjn_na                mjs=0.359
+ mjd=0.359                 pbsws=0.32                pbswd=0.32
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.202
+ mjswd=0.202               pbswgs=0.97               pbswgd=0.97
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.583
+ mjswgd=0.583              tpb=0.00149               tcj=9.05e-04
+ tpbsw=0.000894            tcjsw=0.000809            tpbswg=0.00115
+ tcjswg=0.000928           xtis=3                    xtid=3
+ dmcg=2.05e-007            dmci=3.15e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rshg=8.23                 gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ saref=1.00e-05            sbref=1.00e-05            kvsat=0.8
+ wlod=5.00e-07             tku0=0.03                 ku0=-2.80e-08
+ llodku0=1                 wlodku0=1                 lku0=2.00e-07
+ wku0=3.00e-06             pku0=-5.00e-14            kvth0=1.30e-08
+ stk2=2.50e-09             steta0=-1.10e-10          lkvth0=-1.00e-08
+ wkvth0=1.00e-06           pkvth0=-5.00e-14          llodvth=1
+ wlodvth=1                 lodk2=1                   lodeta0=2
+ rbdb=50                   rbsb=50                   ngcon=1
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     16: type=n 
+ lmin=4.85e-007            lmax=1.2e-006-dxln_na     wmin=2.2e-007
+ wmax=5.3e-007-dxwn_na     version=4.5               ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na              toxm=toxn_na
+ dtox=5.489e-010           epsrox=3.9                wint=-6.1e-009
+ lint=9.298e-009           ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_na
+ xw=0+dxwn_na              dlc=dlcn_na               dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.020835647+dvth0n_na                          lvth0=-1.1198948e-008+dlvth0n_na
+ wvth0=-2.5485058e-010+dwvth0n_na                    pvth0=4.8922085e-015
+ k1=0.042                  k2=0.011276519+dk2n_na    lk2=-1.0401727e-009
+ wk2=-9.0038917e-010+dwk2n_na                        pk2=-2.9984504e-016
+ k3=-2.2                   k3b=0                     w0=0
+ dvt0=9.8                  dvt1=1.336                dvt2=0.09984
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.55                 minv=0                    voffl=0
+ dvtp0=1.532e-005          dvtp1=1                   lpe0=1.759e-007
+ lpeb=3.058e-009           xj=1.6e-007               ngate=9e+019
+ ndep=5.8e+017             nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0                     voff=-0.094701242         lvoff=2.1122512e-008+dlvoffn_na
+ wvoff=2.1889711e-009      pvoff=-8.502974e-015+dpvoffn_na
+ nfactor=1                 eta0=0.21                 etab=-0.0416
+ u0=0.052760645+du0n_na    wu0=4.4673782e-009        ua=1.0203154e-009
+ lua=1.3622514e-016        wua=-1.8196871e-016       pua=1.1731832e-022
+ ub=1.3457674e-018         lub=5.3854776e-026        wub=7.4811601e-025
+ pub=-3.5176557e-031       uc=-1.1618645e-010        luc=5.1574084e-017
+ wuc=-4.6601134e-018       puc=-3.5643684e-024       vsat=247565.19
+ lvsat=-0.015705853        wvsat=-0.011419227        pvsat=1.3319432e-008
+ a0=1.8331457              la0=-3.8858249e-007       ags=-2.7302665
+ lags=6.7548736e-006       wags=1.6801988e-006       pags=-1.5050327e-012
+ a1=0                      a2=0.2021                 b0=0
+ b1=0                      keta=-0.010493704         lketa=-1.2535946e-008
+ wketa=-1.1879138e-008     pketa=9.5877818e-015      dwg=0
+ dwb=0                     pclm=0.67682348           wpclm=5.1821587e-008
+ pdiblc1=0                 pdiblc2=0.0074486026      lpdiblc2=1.1990091e-009
+ wpdiblc2=-3.2748645e-009  ppdiblc2=5.3157791e-015   pdiblcb=0
+ drout=0.5                 pvag=0.309                delta=0.005
+ pscbe1=1e+009             pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=200                  rsw=65.92
+ rdw=65.92                 prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.14
+ beta0=10                  agidl=0                   bgidl=0
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.515e-005           aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.925e-020          nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=1.257                moin=24.64                noff=3.328
+ voffcv=-0.0428            kt1=-0.38761784           lkt1=5.356835e-09
+ wkt1=3.057456e-09         pkt1=-8.6965e-18          kt1l=0
+ kt2=-0.013239267          pkt2=0                    wkt2=-8.122506e-10
+ lkt2=-1.4727816e-09       ute=-1.782                ua1=8.1267718e-010
+ lua1=5.7851072e-016       wua1=1.0887941e-017       pua1=-2.108605e-022
+ ub1=-2.3134319e-18        lub1=-1.4932219e-24       wub1=-3.6245735e-25
+ pub1=5.2087623e-31        uc1=-1.3187543e-011       luc1=-1.2505437e-017
+ wuc1=-6.2258524e-018      puc1=2.9037625e-024       prt=0
+ at=263521.02              lat=-0.060963473          wat=0.0030880447
+ pat=-1.2333784e-09        jss=4.98e-07              jsd=4.98e-07
+ jsws=4.12e-13             jswd=4.12e-13             jswgs=1.0e-12
+ jswgd=1.0e-12             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=11.25                 bvd=11.25
+ xjbvs=1                   xjbvd=1                   pbs=0.6882682
+ pbd=0.6882682             cjs=cjn_na                cjd=cjn_na
+ mjs=0.359                 mjd=0.359                 pbsws=0.32
+ pbswd=0.32                cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.202               mjswd=0.202               pbswgs=0.97
+ pbswgd=0.97               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.583              mjswgd=0.583              tpb=0.00149
+ tcj=9.05e-04              tpbsw=0.000894            tcjsw=0.000809
+ tpbswg=0.00115            tcjswg=0.000928           xtis=3
+ xtid=3                    dmcg=2.05e-007            dmci=3.15e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-3.1e-008             rshg=8.23
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=1.00e-05            sbref=1.00e-05
+ kvsat=0.8                 wlod=5.00e-07             tku0=0.03
+ ku0=-2.80e-08             llodku0=1                 wlodku0=1
+ lku0=2.00e-07             wku0=3.00e-06             pku0=-5.00e-14
+ kvth0=1.30e-08            stk2=2.50e-09             steta0=-1.10e-10
+ lkvth0=-1.00e-08          wkvth0=1.00e-06           pkvth0=-5.00e-14
+ llodvth=1                 wlodvth=1                 lodk2=1
+ lodeta0=2                 lu0=0+dlu0n_na            pu0=0+dpu0n_na
+ fnoimod=1                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=4.10e7                 ef=0.93
+ minr=1e-3
 
 
     } 
endsection mos_na
// 

section mosna5
// *********************************************************************************************
//                                                                            
//                   *
//                                5V Native NMOS DEVICE MODELS                
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
 
// *********************************
//        Mismatch   model         * 
// *********************************
 
inline subckt nanch5_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=2e-007 dmci=2e-007 
+ xw=1e-08 + dxwn_na5 ad=(nf * dmcg + dmci) / factor * (w / nf + xw / factor) as=(nf 
+ * dmcg + dmci) / factor * (w / nf + xw / factor) pd=2 * (nf * dmcg + dmci) / factor 
+ + (nf + 1) * (w / nf + xw / factor) ps=2 * (nf * dmcg + dmci) / factor + (nf + 
+ 1) * (w / nf + xw / factor) nrd=dmcg / factor / nf / (w / nf + xw / factor) nrs=dmcg 
+ / factor / nf / (w / nf + xw / factor) sa=0 / factor sb=0 / factor sd=2 * dmcg 
+ / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor mismatchflag=mismatchflag_mos_na5 
+ temp1=par1n_na5 temp2=par2n_na5 fac1=0.01112 * temp1 * sigma + 0.99994 * temp2 
+ * sigma fac2=0.01112 * temp1 * sigma - 0.99994 * temp2 * sigma lef=l * factor 
+ - 3e-08 wef=w / nf * factor + 1e-08 geo_fac=1 / sqrt(multi * nf * lef * wef * 
+ 1e12) vthmisn_na5=0.0041 * geo_fac * fac1 * mismatchflag dlmisn_na5=0.0024 * geo_fac 
+ * lef * fac2 * mismatchflag dwmisn_na5= - 0.0024 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisn_na5=0.0024 * geo_fac * toxn_na5 * fac2 * mismatchflag 
nanch5_mac ( n1 n2 n3 n4 ) nanch5 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model nanch5 bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_na5+dlmisn_na5                     lmax=900.01e-6
+ wmin=1e-005-dxwn_na5+dwmisn_na5                     wmax=900.01e-6
+ version=4.5               gbmin=1.00e-12            binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_na5+toxmisn_na5 toxm=toxn_na5+toxmisn_na5 dtox=0
+ epsrox=3.9                wint=0                    lint=9.9e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_na5+dlmisn_na5
+ xw=1e-08+dxwn_na5+dwmisn_na5                        dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.083+dvthn_na5+vthmisn_na5
+ k1=0.07                   k2=0.0065085+dk2n_na5     k3=0
+ k3b=-7.7                  w0=0                      dvt0=0.1
+ dvt1=0.053                dvt2=-0.014               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2106
+ minv=-0.3                 voffl=0                   dvtp0=2.721e-010
+ dvtp1=5                   lpe0=4.44089e-021         lpeb=1.177e-006
+ xj=1.5000001e-007         ngate=8e+019              ndep=1e+016
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=6.3492e-005
+ voff=-0.10058             nfactor=1                 eta0=0.36
+ etab=0.011378             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.066845+du0n_na5
+ ua=1.7788e-009            ub=6e-019                 uc=-7.38e-012
+ vsat=128430               a0=1.5108                 ags=0.58933
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.023686            dwg=0
+ dwb=0                     pclm=1.4925               pdiblc1=0
+ pdiblc2=0.00132           pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.01                pscbe1=3.877834e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=250                  prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=0.0005
+ beta0=7.29+dbeta0n_na5    agidl=1e-012              bgidl=1.698e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na5
+ cgdo=cgon_na5             cgbo=0                    cgdl=cgln_na5
+ cgsl=cgln_na5             clc=1e-007                cle=0.6
+ cf=cfn_na5                ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=20                   noff=3
+ voffcv=-0.05              tvoff=0.0051              ltvoff=0
+ wtvoff=0                  ptvoff=0                  kt1=-0.16878
+ kt1l=0                    kt2=-0.01375              ute=-1.185
+ ua1=4.4272e-009           ub1=-5.68e-018            uc1=-6e-011
+ prt=0                     at=-17491                 fnoimod=1
+ tnoimod=0                 em=1.192e+06              ef=1.00
+ noia=7.0e+39              noib=1.5e+25              noic=1e+6
+ lintnoi=-1e-7             jss=2.2e-06               jsd=2.2e-06
+ jsws=9.0e-12              jswd=9.0e-12              jswgs=1.9e-11
+ jswgd=1.9e-11             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=12.0                  bvd=12.0
+ xjbvs=1                   xjbvd=1                   jtsswgs=5e-012
+ jtsswgd=5e-012            njtsswg=19                xtsswgs=0.62
+ xtsswgd=0.62              tnjtsswg=1                vtsswgs=10.147
+ vtsswgd=10.147            pbs=0.568                 pbd=0.568
+ cjs=cjn_na5               cjd=cjn_na5               mjs=0.396
+ mjd=0.396                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_na5           cjswd=cjswn_na5           mjsws=0.101
+ mjswd=0.101               pbswgs=1.000              pbswgd=1.000
+ cjswgs=cjswgn_na5         cjswgd=cjswgn_na5         mjswgs=0.850
+ mjswgd=0.850              tpb=2.1e-03               tcj=2.0e-03
+ tpbsw=1.5e-03             tcjsw=5.0e-04             tpbswg=5.0e-04
+ tcjswg=1.0e-03            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   pu0=0+dpu0n_na5           wu0=0+dwu0n_na5
+ lu0=0+dlu0n_na5           lvth0=0+dlvthn_na5        wvth0=0+dwvthn_na5
+ pvth0=0+dpvthn_na5        lvsat=0+dlvsatn_na5       pvsat=0+dpvsatn_na5
+ rshg=8.23                 minr=1e-3
 
     2: type=n 
+ lmin=2e-006-dxln_na5+dlmisn_na5                     lmax=1e-005-dxln_na5+dlmisn_na5
+ wmin=1e-005-dxwn_na5+dwmisn_na5                     wmax=900.01e-6
+ version=4.5               gbmin=1.00e-12            binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_na5+toxmisn_na5 toxm=toxn_na5+toxmisn_na5 dtox=0
+ epsrox=3.9                wint=0                    lint=9.9e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_na5+dlmisn_na5
+ xw=1e-08+dxwn_na5+dwmisn_na5                        dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.082490107+dvthn_na5+vthmisn_na5
+ lvth0=-4.9826744e-009+dlvthn_na5                    k1=0.07
+ k2=0.0077286328+dk2n_na5  lk2=-1.1923137e-008       k3=0
+ k3b=-7.7                  w0=0                      dvt0=0.1
+ dvt1=0.053                dvt2=-0.014               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2106
+ minv=-0.3                 voffl=0                   dvtp0=2.721e-010
+ dvtp1=5                   lpe0=4.44089e-021         lpeb=1.177e-006
+ xj=1.5000001e-007         ngate=8e+019              ndep=1e+016
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-3.881212e-006
+ lcit=6.5837103e-010       voff=-0.10079308          lvoff=2.0822471e-009
+ nfactor=1                 eta0=0.3559244            leta0=3.9826763e-008
+ etab=0.011378             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.065716679+du0n_na5
+ lu0=1.1025953e-008+dlu0n_na5                        ua=1.5901928e-009
+ lua=1.8430701e-015        ub=7.4967951e-019         lub=-1.4626682e-024
+ uc=-7.8231108e-012        luc=4.3300783e-018        vsat=134933.24
+ lvsat=-0.063549661+dlvsatn_na5                      a0=2.8997601
+ la0=-1.3572918e-005       ags=0.66695025            lags=-7.5850503e-007
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.028005339         lketa=4.2208577e-008
+ dwg=0                     dwb=0                     pclm=1.7961987
+ lpclm=-2.9677432e-006     pdiblc1=0                 pdiblc2=0.00108964
+ lpdiblc2=2.2510779e-009   pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.01                pscbe1=3.877834e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=250                  prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=-0.0009771835
+ lalpha1=1.4435037e-008    beta0=6.8042505+dbeta0n_na5
+ lbeta0=4.7467441e-006     agidl=1e-012              bgidl=1.698e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na5
+ cgdo=cgon_na5             cgbo=0                    cgdl=cgln_na5
+ cgsl=cgln_na5             clc=1e-007                cle=0.6
+ cf=cfn_na5                ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=20                   noff=3
+ voffcv=-0.05              tvoff=0.00512215          ltvoff=-2.164498e-010
+ wtvoff=0                  ptvoff=0                  kt1=-0.16845218
+ lkt1=-3.203457e-009       kt1l=0                    kt2=-0.013582989
+ lkt2=-1.6320315e-009      ute=-1.1816775            lute=-3.246747e-008
+ ua1=4.7612885e-009        lua1=-3.2647123e-015      ub1=-6.26476e-018
+ lub1=5.7142747e-024       uc1=-7.840665e-011        luc1=1.7986978e-016
+ prt=0                     at=-17491                 fnoimod=1
+ tnoimod=0                 em=1.192e+06              ef=1.00
+ noia=7.0e+39              noib=1.5e+25              noic=1e+6
+ lintnoi=-1e-7             jss=2.2e-06               jsd=2.2e-06
+ jsws=9.0e-12              jswd=9.0e-12              jswgs=1.9e-11
+ jswgd=1.9e-11             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=12.0                  bvd=12.0
+ xjbvs=1                   xjbvd=1                   jtsswgs=5e-012
+ jtsswgd=5e-012            njtsswg=19                xtsswgs=0.62
+ xtsswgd=0.62              tnjtsswg=1                vtsswgs=10.147
+ vtsswgd=10.147            pbs=0.568                 pbd=0.568
+ cjs=cjn_na5               cjd=cjn_na5               mjs=0.396
+ mjd=0.396                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_na5           cjswd=cjswn_na5           mjsws=0.101
+ mjswd=0.101               pbswgs=1.000              pbswgd=1.000
+ cjswgs=cjswgn_na5         cjswgd=cjswgn_na5         mjswgs=0.850
+ mjswgd=0.850              tpb=2.1e-03               tcj=2.0e-03
+ tpbsw=1.5e-03             tcjsw=5.0e-04             tpbswg=5.0e-04
+ tcjswg=1.0e-03            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   pu0=0+dpu0n_na5           wu0=0+dwu0n_na5
+ wvth0=0+dwvthn_na5        pvth0=0+dpvthn_na5        pvsat=0+dpvsatn_na5
+ rshg=8.23                 minr=1e-3
 
     3: type=n 
+ lmin=1.6e-06              lmax=2e-006-dxln_na5+dlmisn_na5
+ wmin=1e-005-dxwn_na5+dwmisn_na5                     wmax=900.01e-6
+ version=4.5               gbmin=1.00e-12            binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_na5+toxmisn_na5 toxm=toxn_na5+toxmisn_na5 dtox=0
+ epsrox=3.9                wint=0                    lint=9.9e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_na5+dlmisn_na5
+ xw=1e-08+dxwn_na5+dwmisn_na5                        dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.00376824+dvthn_na5+vthmisn_na5
+ lvth0=-1.5783247e-007+dlvthn_na5                    k1=0.07
+ k2=-0.01958+dk2n_na5      lk2=3.646776e-008         k3=0
+ k3b=-7.7                  w0=0                      dvt0=0.1
+ dvt1=0.053                dvt2=-0.014               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2106
+ minv=-0.3                 voffl=0                   dvtp0=2.721e-010
+ dvtp1=5                   lpe0=4.44089e-021         lpeb=1.177e-006
+ xj=1.5000001e-007         ngate=8e+019              ndep=1e+016
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0008934138
+ lcit=2.2346228e-009       voff=-0.12434144          lvoff=4.3809936e-008
+ nfactor=1                 eta0=0.3784               etab=0.011378
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.06919843+du0n_na5    lu0=4.85629e-009+dlu0n_na5
+ ua=1.911029e-009          lua=1.2745482e-015        ub=1.149148e-020
+ lub=-1.5459899e-025       uc=4.024188e-012          luc=-1.6663335e-017
+ vsat=123320.1             lvsat=-0.042971177+dlvsatn_na5
+ a0=-18.228035             la0=2.3865535e-005        ags=0.509527
+ lags=-4.7955104e-007      a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=0.006779424
+ lketa=-1.9430023e-008     dwg=0                     dwb=0
+ pclm=0.2029311            lpclm=-1.4447311e-007     pdiblc1=0
+ pdiblc2=0.0086712         lpdiblc2=-1.1183446e-008  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=3.877834e+008      pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=250                  prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=-0.03692708        lalpha1=7.8138254e-008    beta0=-0.02496+dbeta0n_na5
+ lbeta0=1.6848105e-005     agidl=1e-012              bgidl=1.698e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na5
+ cgdo=cgon_na5             cgbo=0                    cgdl=cgln_na5
+ cgsl=cgln_na5             clc=1e-007                cle=0.6
+ cf=cfn_na5                ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=20                   noff=3
+ voffcv=-0.05              tvoff=-0.000592615        ltvoff=9.9101138e-009
+ wtvoff=0                  ptvoff=0                  kt1=-0.2428731
+ lkt1=1.2867041e-007       kt1l=0                    kt2=-0.0169393
+ lkt2=4.3153516e-009       ute=-1.2                  ua1=3.119898e-009
+ lua1=-3.5616846e-016      ub1=-4.35369e-018         lub1=2.3278587e-024
+ uc1=-4.3785e-011          luc1=1.1852022e-016       prt=0
+ at=-71602.68              lat=0.095885897           fnoimod=1
+ tnoimod=0                 em=1.192e+06              ef=1.00
+ noia=7.0e+39              noib=1.5e+25              noic=1e+6
+ lintnoi=-1e-7             jss=2.2e-06               jsd=2.2e-06
+ jsws=9.0e-12              jswd=9.0e-12              jswgs=1.9e-11
+ jswgd=1.9e-11             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=12.0                  bvd=12.0
+ xjbvs=1                   xjbvd=1                   jtsswgs=5e-012
+ jtsswgd=5e-012            njtsswg=19                xtsswgs=0.62
+ xtsswgd=0.62              tnjtsswg=1                vtsswgs=10.147
+ vtsswgd=10.147            pbs=0.568                 pbd=0.568
+ cjs=cjn_na5               cjd=cjn_na5               mjs=0.396
+ mjd=0.396                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_na5           cjswd=cjswn_na5           mjsws=0.101
+ mjswd=0.101               pbswgs=1.000              pbswgd=1.000
+ cjswgs=cjswgn_na5         cjswgd=cjswgn_na5         mjswgs=0.850
+ mjswgd=0.850              tpb=2.1e-03               tcj=2.0e-03
+ tpbsw=1.5e-03             tcjsw=5.0e-04             tpbswg=5.0e-04
+ tcjswg=1.0e-03            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   pu0=0+dpu0n_na5           wu0=0+dwu0n_na5
+ wvth0=0+dwvthn_na5        pvth0=0+dpvthn_na5        pvsat=0+dpvsatn_na5
+ rshg=8.23                 minr=1e-3
 
     4: type=n 
+ lmin=1e-005-dxln_na5+dlmisn_na5                     lmax=900.01e-6
+ wmin=1.2e-06              wmax=1e-005-dxwn_na5+dwmisn_na5
+ version=4.5               gbmin=1.00e-12            binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_na5+toxmisn_na5 toxm=toxn_na5+toxmisn_na5 dtox=0
+ epsrox=3.9                wint=0                    lint=9.9e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_na5+dlmisn_na5
+ xw=1e-08+dxwn_na5+dwmisn_na5                        dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.089115588+dvthn_na5+vthmisn_na5
+ wvth0=6.1217031e-008+dwvthn_na5                     k1=0.07
+ k2=0.007580945+dk2n_na5   wk2=-1.0735175e-008       k3=0
+ k3b=-7.7                  w0=0                      dvt0=0.1
+ dvt1=0.053                dvt2=-0.014               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2106
+ minv=-0.3                 voffl=0                   dvtp0=2.721e-010
+ dvtp1=5                   lpe0=4.44089e-021         lpeb=1.177e-006
+ xj=1.5000001e-007         ngate=8e+019              ndep=1e+016
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5.0814775e-005
+ wcit=1.2689902e-010       voff=-0.0986165           wvoff=-1.9654635e-008
+ nfactor=1                 eta0=0.39538563           weta0=-3.5421011e-007
+ etab=0.012993408          wetab=-1.6170232e-008     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.067639063+du0n_na5   wu0=-7.9485656e-009+dwu0n_na5
+ ua=1.8195688e-009         wua=-4.0809519e-016       ub=5.7888825e-019
+ wub=2.1132862e-025        uc=-6.1871875e-012        wuc=-1.1940053e-017
+ vsat=130514.5             wvsat=-0.020865845        a0=1.5933055
+ wa0=-8.2588006e-007       ags=0.61317113            wags=-2.3864966e-007
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.025010263         wketa=1.3255868e-008
+ dwg=0                     dwb=0                     pclm=1.4925
+ pdiblc1=0                 pdiblc2=0.00145475        wpdiblc2=-1.3488475e-009
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.01                pscbe1=3.877834e+008      pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=250
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=-0.00083375        walpha1=1.3350838e-008
+ beta0=6.6894+dbeta0n_na5  wbeta0=6.012006e-006      agidl=1e-012
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na5             cgdo=cgon_na5             cgbo=0
+ cgdl=cgln_na5             cgsl=cgln_na5             clc=1e-007
+ cle=0.6                   cf=cfn_na5                ckappas=0.6
+ ckappad=0.6               acde=0.55                 moin=20
+ noff=3                    voffcv=-0.05              tvoff=0.0053534263
+ ltvoff=0                  wtvoff=-2.5367968e-009    ptvoff=0
+ kt1=-0.16801688           wkt1=-7.6388813e-009      kt1l=0
+ kt2=-0.012203125          wkt2=-1.5484219e-008      ute=-1.185
+ ua1=4.615905e-009         wua1=-1.8889371e-015      ub1=-6.03926e-018
+ wub1=3.5961926e-024       uc1=-6e-011               prt=0
+ at=-17475.875             wat=-0.00015140125        fnoimod=1
+ tnoimod=0                 em=1.192e+06              ef=1.00
+ noia=7.0e+39              noib=1.5e+25              noic=1e+6
+ lintnoi=-1e-7             jss=2.2e-06               jsd=2.2e-06
+ jsws=9.0e-12              jswd=9.0e-12              jswgs=1.9e-11
+ jswgd=1.9e-11             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=12.0                  bvd=12.0
+ xjbvs=1                   xjbvd=1                   jtsswgs=5e-012
+ jtsswgd=5e-012            njtsswg=19                xtsswgs=0.62
+ xtsswgd=0.62              tnjtsswg=1                vtsswgs=10.147
+ vtsswgd=10.147            pbs=0.568                 pbd=0.568
+ cjs=cjn_na5               cjd=cjn_na5               mjs=0.396
+ mjd=0.396                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_na5           cjswd=cjswn_na5           mjsws=0.101
+ mjswd=0.101               pbswgs=1.000              pbswgd=1.000
+ cjswgs=cjswgn_na5         cjswgd=cjswgn_na5         mjswgs=0.850
+ mjswgd=0.850              tpb=2.1e-03               tcj=2.0e-03
+ tpbsw=1.5e-03             tcjsw=5.0e-04             tpbswg=5.0e-04
+ tcjswg=1.0e-03            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   pu0=0+dpu0n_na5           lu0=0+dlu0n_na5
+ lvth0=0+dlvthn_na5        pvth0=0+dpvthn_na5        lvsat=0+dlvsatn_na5
+ pvsat=0+dpvsatn_na5       rshg=8.23                 minr=1e-3
 
     5: type=n 
+ lmin=2e-006-dxln_na5+dlmisn_na5                     lmax=1e-005-dxln_na5+dlmisn_na5
+ wmin=1.2e-06              wmax=1e-005-dxwn_na5+dwmisn_na5
+ version=4.5               gbmin=1.00e-12            binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_na5+toxmisn_na5 toxm=toxn_na5+toxmisn_na5 dtox=0
+ epsrox=3.9                wint=0                    lint=9.9e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_na5+dlmisn_na5
+ xw=1e-08+dxwn_na5+dwmisn_na5                        dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.08822822+dvthn_na5+vthmisn_na5
+ lvth0=-8.6713578e-009+dlvthn_na5                    wvth0=5.7438509e-008+dwvthn_na5
+ pvth0=3.6923721e-014+dpvthn_na5                     k1=0.07
+ k2=0.0088254306+dk2n_na5  lk2=-1.2161113e-008       wk2=-1.0978946e-008
+ pk2=2.3821371e-015        k3=0                      k3b=-7.7
+ w0=0                      dvt0=0.1                  dvt1=0.053
+ dvt2=-0.014               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2106               minv=-0.3
+ voffl=0                   dvtp0=2.721e-010          dvtp1=5
+ lpe0=4.44089e-021         lpeb=1.177e-006           xj=1.5000001e-007
+ ngate=8e+019              ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-2.6658887e-005       lcit=7.5707262e-010
+ wcit=2.2800453e-010       pcit=-9.8800297e-016      voff=-0.099226184
+ lvoff=5.9578349e-009      wvoff=-1.5684656e-008     pvoff=-3.8794634e-014
+ nfactor=1                 eta0=0.39074963           leta0=4.5302943e-008
+ weta0=-3.4860055e-007     peta0=-5.4816561e-014     etab=0.012993408
+ wetab=-1.6170232e-008     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.066495239+du0n_na5
+ lu0=1.1177441e-008+dlu0n_na5                        wu0=-7.7933883e-009+dwu0n_na5
+ pu0=-1.5163929e-015+dpu0n_na5                       ua=1.6276966e-009
+ lua=1.8749748e-015        wua=-3.7541344e-016       pua=-3.1936605e-022
+ ub=7.3378169e-019         lub=-1.5136187e-024       wub=1.5913721e-025
+ pub=5.1001448e-031        uc=-7.3447257e-012        luc=1.1311464e-017
+ wuc=-4.788634e-018        puc=-6.9883668e-023       vsat=137331.14
+ lvsat=-0.066612155+dlvsatn_na5                      wvsat=-0.024002927
+ pvsat=3.0655566e-008+dpvsatn_na5                    a0=3.0913367
+ la0=-1.4638761e-005       wa0=-1.9176822e-006       pa0=1.066909e-011
+ ags=0.6942579             lags=-7.9237997e-007      wags=-2.7334963e-007
+ pags=3.390881e-013        a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.02992351
+ lketa=4.8012256e-008      wketa=1.9200897e-008      pketa=-5.809483e-014
+ dwg=0                     dwb=0                     pclm=1.8161384
+ lpclm=-3.162594e-006      wpclm=-1.9959647e-007     ppclm=1.9504567e-012
+ pdiblc1=0                 pdiblc2=0.0012219535      lpdiblc2=2.2748874e-009
+ wpdiblc2=-1.3244581e-009  ppdiblc2=-2.3833288e-016  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=3.877834e+008      pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=250                  prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=-0.0017438077      lalpha1=8.8930835e-009    walpha1=7.6739079e-009
+ palpha1=5.5474956e-014    beta0=6.1801687+dbeta0n_na5
+ lbeta0=4.976208e-006      wbeta0=6.2470585e-006     pbeta0=-2.2969331e-012
+ agidl=1e-012              bgidl=1.698e+009          cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na5             cgdo=cgon_na5
+ cgbo=0                    cgdl=cgln_na5             cgsl=cgln_na5
+ clc=1e-007                cle=0.6                   cf=cfn_na5
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=20                   noff=3                    voffcv=-0.05
+ tvoff=0.0054347558        ltvoff=-7.9475226e-010    wtvoff=-3.129184e-009
+ ptvoff=5.7888076e-015     kt1=-0.16696085           lkt1=-1.0319515e-008
+ wkt1=-1.4928253e-008      pkt1=7.1231738e-014       kt1l=0
+ kt2=-0.01201315           lkt2=-1.8564358e-009      wkt2=-1.5714089e-008
+ pkt2=2.2462873e-015       ute=-1.1812207            lute=-3.6931747e-008
+ wute=-4.5730059e-009      pute=4.4687414e-014       ua1=4.9764051e-009
+ lua1=-3.5228071e-015      wua1=-2.1533178e-015      pua1=2.5835284e-021
+ ub1=-6.7026946e-018       lub1=6.4830828e-024       wub1=4.3837252e-024
+ pub1=-7.6957685e-030      uc1=-8.0937564e-011       luc1=2.0460188e-016
+ wuc1=2.5334453e-017       puc1=-2.4756827e-022      prt=0
+ at=-17378.415             lat=-0.00095237912        wat=-0.0011269759
+ pat=9.533315e-009         fnoimod=1                 tnoimod=0
+ em=1.192e+06              ef=1.00                   noia=7.0e+39
+ noib=1.5e+25              noic=1e+6                 lintnoi=-1e-7
+ jss=2.2e-06               jsd=2.2e-06               jsws=9.0e-12
+ jswd=9.0e-12              jswgs=1.9e-11             jswgd=1.9e-11
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=12.0                  bvd=12.0                  xjbvs=1
+ xjbvd=1                   jtsswgs=5e-012            jtsswgd=5e-012
+ njtsswg=19                xtsswgs=0.62              xtsswgd=0.62
+ tnjtsswg=1                vtsswgs=10.147            vtsswgd=10.147
+ pbs=0.568                 pbd=0.568                 cjs=cjn_na5
+ cjd=cjn_na5               mjs=0.396                 mjd=0.396
+ pbsws=0.406               pbswd=0.406               cjsws=cjswn_na5
+ cjswd=cjswn_na5           mjsws=0.101               mjswd=0.101
+ pbswgs=1.000              pbswgd=1.000              cjswgs=cjswgn_na5
+ cjswgd=cjswgn_na5         mjswgs=0.850              mjswgd=0.850
+ tpb=2.1e-03               tcj=2.0e-03               tpbsw=1.5e-03
+ tcjsw=5.0e-04             tpbswg=5.0e-04            tcjswg=1.0e-03
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ rshg=8.23                 minr=1e-3
 
     6: type=n 
+ lmin=1.6e-06              lmax=2e-006-dxln_na5+dlmisn_na5
+ wmin=1.2e-06              wmax=1e-005-dxwn_na5+dwmisn_na5
+ version=4.5               gbmin=1.00e-12            binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  geomod=0
+ diomod=1                  rdsmod=0                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_na5+toxmisn_na5 toxm=toxn_na5+toxmisn_na5 dtox=0
+ epsrox=3.9                wint=0                    lint=9.9e-008
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     wwc=0                     xl=-3e-08+dxln_na5+dlmisn_na5
+ xw=1e-08+dxwn_na5+dwmisn_na5                        dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.011663494+dvthn_na5+vthmisn_na5
+ lvth0=-1.8567948e-007+dlvthn_na5                    wvth0=-7.9031494e-008+dwvthn_na5
+ pvth0=2.7874857e-013+dpvthn_na5                     k1=0.07
+ k2=-0.019089125+dk2n_na5  lk2=3.730348e-008         wk2=-4.9136588e-009
+ pk2=-8.3655522e-015       k3=0                      k3b=-7.3698625
+ lk3b=-5.8500365e-007      wk3b=-3.3046764e-006      pk3b=5.8558865e-012
+ w0=0                      dvt0=0.1                  dvt1=0.053
+ dvt2=-0.014               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2106               minv=-0.3
+ voffl=0                   dvtp0=2.721e-010          dvtp1=5
+ lpe0=4.44089e-021         lpeb=1.177e-006           xj=1.5000001e-007
+ ngate=8e+019              ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.0010079727         lcit=2.4959606e-009
+ wcit=1.1467341e-009       pcit=-2.6159918e-015      voff=-0.12626012
+ lvoff=5.386197e-008       wvoff=1.9205992e-008      pvoff=-1.0062086e-013
+ nfactor=1                 eta0=0.41631563           weta0=-3.7953541e-007
+ etab=0.012993408          wetab=-1.6170232e-008     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.068990005+du0n_na5   lu0=6.7567162e-009+dlu0n_na5
+ wu0=2.0863368e-009+dwu0n_na5                        pu0=-1.9023266e-014+dpu0n_na5
+ ua=1.8782496e-009         lua=1.4309949e-015        wua=3.281223e-016
+ pua=-1.5660314e-021       ub=-1.0637404e-019        lub=-2.4862731e-026
+ wub=1.1798338e-024        pub=-1.29866e-030         uc=9.7354139e-012
+ luc=-1.8954544e-017       wuc=-5.7169371e-017       puc=2.2934998e-023
+ vsat=122654.08            lvsat=-0.04060442+dlvsatn_na5
+ wvsat=0.0066668302        pvsat=-2.3691244e-008+dpvsatn_na5
+ a0=-21.179995             la0=2.8370038e-005        wa0=2.9549116e-005
+ pa0=-4.5090075e-011       ags=0.56306934            lags=-5.5991383e-007
+ wags=-5.3595877e-007      pags=8.044315e-013        a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=0.0096441573         lketa=-2.2101651e-008     wketa=-2.867598e-008
+ pketa=2.6742997e-014      dwg=0                     dwb=0
+ pclm=0.09849699           lpclm=-1.1893352e-007     wpclm=1.0453854e-006
+ ppclm=-2.5565128e-013     pdiblc1=0                 pdiblc2=0.00911879
+ lpdiblc2=-1.1718307e-008  wpdiblc2=-4.4803759e-009  ppdiblc2=5.3539534e-015
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.01                pscbe1=3.877834e+008      pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=250
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=-0.034389667       lalpha1=6.6741547e-008
+ walpha1=-2.53995e-008     palpha1=1.1408104e-013    beta0=-1.4047876+dbeta0n_na5
+ lbeta0=1.8416751e-005     wbeta0=1.3812075e-005     pbeta0=-1.5702142e-011
+ agidl=1e-012              bgidl=1.698e+009          cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na5             cgdo=cgon_na5
+ cgbo=0                    cgdl=cgln_na5             cgsl=cgln_na5
+ clc=1e-007                cle=0.6                   cf=cfn_na5
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=20                   noff=3                    voffcv=-0.05
+ tvoff=-0.0013753496       ltvoff=1.1272754e-008     wtvoff=7.835173e-009
+ ptvoff=-1.3640033e-014    kt1=-0.26334293           lkt1=1.6046954e-007
+ wkt1=2.0490301e-007       pkt1=-3.1830926e-013      kt1l=0
+ kt2=-0.012057954          lkt2=-1.7770436e-009      wkt2=-4.8862276e-008
+ pkt2=6.0984876e-014       ute=-1.2020625            wute=2.0645625e-008
+ ua1=3.3940483e-009        lua1=-7.1887072e-016      wua1=-2.744244e-015
+ pua1=3.6306497e-021       ub1=-4.4589707e-018       lub1=2.5072041e-024
+ wub1=1.0538601e-024       pub1=-1.7952475e-030      uc1=-4.1555438e-011
+ luc1=1.3481675e-016       wuc1=-2.2317921e-017      puc1=-1.6312827e-022
+ prt=0                     at=-77075.593             lat=0.10483102
+ wat=0.054783861           pat=-8.9540688e-008       fnoimod=1
+ tnoimod=0                 em=1.192e+06              ef=1.00
+ noia=7.0e+39              noib=1.5e+25              noic=1e+6
+ lintnoi=-1e-7             jss=2.2e-06               jsd=2.2e-06
+ jsws=9.0e-12              jswd=9.0e-12              jswgs=1.9e-11
+ jswgd=1.9e-11             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=12.0                  bvd=12.0
+ xjbvs=1                   xjbvd=1                   jtsswgs=5e-012
+ jtsswgd=5e-012            njtsswg=19                xtsswgs=0.62
+ xtsswgd=0.62              tnjtsswg=1                vtsswgs=10.147
+ vtsswgd=10.147            pbs=0.568                 pbd=0.568
+ cjs=cjn_na5               cjd=cjn_na5               mjs=0.396
+ mjd=0.396                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_na5           cjswd=cjswn_na5           mjsws=0.101
+ mjswd=0.101               pbswgs=1.000              pbswgd=1.000
+ cjswgs=cjswgn_na5         cjswgd=cjswgn_na5         mjswgs=0.850
+ mjswgd=0.850              tpb=2.1e-03               tcj=2.0e-03
+ tpbsw=1.5e-03             tcjsw=5.0e-04             tpbswg=5.0e-04
+ tcjswg=1.0e-03            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   rshg=8.23                 minr=1e-3
 
     } 
ends nanch5_mac
//   // *********************************************************************************************
//                                                                            
//                   *
//                                5V Native NMOS DEVICE MODELS                
//                   *
//                                                                            
//                   *
// *********************************************************************************************
model nanch5 bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_na5      lmax=900.01e-6            wmin=1e-005-dxwn_na5
+ wmax=900.01e-6            version=4.5               gbmin=1.00e-12
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ geomod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na5             toxm=toxn_na5
+ dtox=0                    epsrox=3.9                wint=0
+ lint=9.9e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_na5        xw=1e-08+dxwn_na5         dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.083+dvthn_na5     k1=0.07
+ k2=0.0065085+dk2n_na5     k3=0                      k3b=-7.7
+ w0=0                      dvt0=0.1                  dvt1=0.053
+ dvt2=-0.014               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2106               minv=-0.3
+ voffl=0                   dvtp0=2.721e-010          dvtp1=5
+ lpe0=4.44089e-021         lpeb=1.177e-006           xj=1.5000001e-007
+ ngate=8e+019              ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=6.3492e-005           voff=-0.10058
+ nfactor=1                 eta0=0.36                 etab=0.011378
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.066845+du0n_na5      ua=1.7788e-009
+ ub=6e-019                 uc=-7.38e-012             vsat=128430
+ a0=1.5108                 ags=0.58933               a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=-0.023686            dwg=0                     dwb=0
+ pclm=1.4925               pdiblc1=0                 pdiblc2=0.00132
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.01                pscbe1=3.877834e+008      pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=250
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=0.0005             beta0=7.29+dbeta0n_na5
+ agidl=1e-012              bgidl=1.698e+009          cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na5             cgdo=cgon_na5
+ cgbo=0                    cgdl=cgln_na5             cgsl=cgln_na5
+ clc=1e-007                cle=0.6                   cf=cfn_na5
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=20                   noff=3                    voffcv=-0.05
+ tvoff=0.0051              ltvoff=0                  wtvoff=0
+ ptvoff=0                  kt1=-0.16878              kt1l=0
+ kt2=-0.01375              ute=-1.185                ua1=4.4272e-009
+ ub1=-5.68e-018            uc1=-6e-011               prt=0
+ at=-17491                 fnoimod=1                 tnoimod=0
+ em=1.192e+06              ef=1.00                   noia=7.0e+39
+ noib=1.5e+25              noic=1e+6                 lintnoi=-1e-7
+ jss=2.2e-06               jsd=2.2e-06               jsws=9.0e-12
+ jswd=9.0e-12              jswgs=1.9e-11             jswgd=1.9e-11
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=12.0                  bvd=12.0                  xjbvs=1
+ xjbvd=1                   jtsswgs=5e-012            jtsswgd=5e-012
+ njtsswg=19                xtsswgs=0.62              xtsswgd=0.62
+ tnjtsswg=1                vtsswgs=10.147            vtsswgd=10.147
+ pbs=0.568                 pbd=0.568                 cjs=cjn_na5
+ cjd=cjn_na5               mjs=0.396                 mjd=0.396
+ pbsws=0.406               pbswd=0.406               cjsws=cjswn_na5
+ cjswd=cjswn_na5           mjsws=0.101               mjswd=0.101
+ pbswgs=1.000              pbswgd=1.000              cjswgs=cjswgn_na5
+ cjswgd=cjswgn_na5         mjswgs=0.850              mjswgd=0.850
+ tpb=2.1e-03               tcj=2.0e-03               tpbsw=1.5e-03
+ tcjsw=5.0e-04             tpbswg=5.0e-04            tcjswg=1.0e-03
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ pu0=0+dpu0n_na5           wu0=0+dwu0n_na5           lu0=0+dlu0n_na5
+ lvth0=0+dlvthn_na5        wvth0=0+dwvthn_na5        pvth0=0+dpvthn_na5
+ lvsat=0+dlvsatn_na5       pvsat=0+dpvsatn_na5       rshg=8.23
+ minr=1e-3
 
     2: type=n 
+ lmin=2e-006-dxln_na5      lmax=1e-005-dxln_na5      wmin=1e-005-dxwn_na5
+ wmax=900.01e-6            version=4.5               gbmin=1.00e-12
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ geomod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na5             toxm=toxn_na5
+ dtox=0                    epsrox=3.9                wint=0
+ lint=9.9e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_na5        xw=1e-08+dxwn_na5         dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.082490107+dvthn_na5
+ lvth0=-4.9826744e-009+dlvthn_na5                    k1=0.07
+ k2=0.0077286328+dk2n_na5  lk2=-1.1923137e-008       k3=0
+ k3b=-7.7                  w0=0                      dvt0=0.1
+ dvt1=0.053                dvt2=-0.014               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2106
+ minv=-0.3                 voffl=0                   dvtp0=2.721e-010
+ dvtp1=5                   lpe0=4.44089e-021         lpeb=1.177e-006
+ xj=1.5000001e-007         ngate=8e+019              ndep=1e+016
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-3.881212e-006
+ lcit=6.5837103e-010       voff=-0.10079308          lvoff=2.0822471e-009
+ nfactor=1                 eta0=0.3559244            leta0=3.9826763e-008
+ etab=0.011378             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.065716679+du0n_na5
+ lu0=1.1025953e-008+dlu0n_na5                        ua=1.5901928e-009
+ lua=1.8430701e-015        ub=7.4967951e-019         lub=-1.4626682e-024
+ uc=-7.8231108e-012        luc=4.3300783e-018        vsat=134933.24
+ lvsat=-0.063549661+dlvsatn_na5                      a0=2.8997601
+ la0=-1.3572918e-005       ags=0.66695025            lags=-7.5850503e-007
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.028005339         lketa=4.2208577e-008
+ dwg=0                     dwb=0                     pclm=1.7961987
+ lpclm=-2.9677432e-006     pdiblc1=0                 pdiblc2=0.00108964
+ lpdiblc2=2.2510779e-009   pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.01                pscbe1=3.877834e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=250                  prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=-0.0009771835
+ lalpha1=1.4435037e-008    beta0=6.8042505+dbeta0n_na5
+ lbeta0=4.7467441e-006     agidl=1e-012              bgidl=1.698e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na5
+ cgdo=cgon_na5             cgbo=0                    cgdl=cgln_na5
+ cgsl=cgln_na5             clc=1e-007                cle=0.6
+ cf=cfn_na5                ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=20                   noff=3
+ voffcv=-0.05              tvoff=0.00512215          ltvoff=-2.164498e-010
+ wtvoff=0                  ptvoff=0                  kt1=-0.16845218
+ lkt1=-3.203457e-009       kt1l=0                    kt2=-0.013582989
+ lkt2=-1.6320315e-009      ute=-1.1816775            lute=-3.246747e-008
+ ua1=4.7612885e-009        lua1=-3.2647123e-015      ub1=-6.26476e-018
+ lub1=5.7142747e-024       uc1=-7.840665e-011        luc1=1.7986978e-016
+ prt=0                     at=-17491                 fnoimod=1
+ tnoimod=0                 em=1.192e+06              ef=1.00
+ noia=7.0e+39              noib=1.5e+25              noic=1e+6
+ lintnoi=-1e-7             jss=2.2e-06               jsd=2.2e-06
+ jsws=9.0e-12              jswd=9.0e-12              jswgs=1.9e-11
+ jswgd=1.9e-11             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=12.0                  bvd=12.0
+ xjbvs=1                   xjbvd=1                   jtsswgs=5e-012
+ jtsswgd=5e-012            njtsswg=19                xtsswgs=0.62
+ xtsswgd=0.62              tnjtsswg=1                vtsswgs=10.147
+ vtsswgd=10.147            pbs=0.568                 pbd=0.568
+ cjs=cjn_na5               cjd=cjn_na5               mjs=0.396
+ mjd=0.396                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_na5           cjswd=cjswn_na5           mjsws=0.101
+ mjswd=0.101               pbswgs=1.000              pbswgd=1.000
+ cjswgs=cjswgn_na5         cjswgd=cjswgn_na5         mjswgs=0.850
+ mjswgd=0.850              tpb=2.1e-03               tcj=2.0e-03
+ tpbsw=1.5e-03             tcjsw=5.0e-04             tpbswg=5.0e-04
+ tcjswg=1.0e-03            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   pu0=0+dpu0n_na5           wu0=0+dwu0n_na5
+ wvth0=0+dwvthn_na5        pvth0=0+dpvthn_na5        pvsat=0+dpvsatn_na5
+ rshg=8.23                 minr=1e-3
 
     3: type=n 
+ lmin=1.6e-06              lmax=2e-006-dxln_na5      wmin=1e-005-dxwn_na5
+ wmax=900.01e-6            version=4.5               gbmin=1.00e-12
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ geomod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na5             toxm=toxn_na5
+ dtox=0                    epsrox=3.9                wint=0
+ lint=9.9e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_na5        xw=1e-08+dxwn_na5         dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.00376824+dvthn_na5 lvth0=-1.5783247e-007+dlvthn_na5
+ k1=0.07                   k2=-0.01958+dk2n_na5      lk2=3.646776e-008
+ k3=0                      k3b=-7.7                  w0=0
+ dvt0=0.1                  dvt1=0.053                dvt2=-0.014
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.2106               minv=-0.3                 voffl=0
+ dvtp0=2.721e-010          dvtp1=5                   lpe0=4.44089e-021
+ lpeb=1.177e-006           xj=1.5000001e-007         ngate=8e+019
+ ndep=1e+016               nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.0008934138         lcit=2.2346228e-009       voff=-0.12434144
+ lvoff=4.3809936e-008      nfactor=1                 eta0=0.3784
+ etab=0.011378             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.06919843+du0n_na5
+ lu0=4.85629e-009+dlu0n_na5                          ua=1.911029e-009
+ lua=1.2745482e-015        ub=1.149148e-020          lub=-1.5459899e-025
+ uc=4.024188e-012          luc=-1.6663335e-017       vsat=123320.1
+ lvsat=-0.042971177+dlvsatn_na5                      a0=-18.228035
+ la0=2.3865535e-005        ags=0.509527              lags=-4.7955104e-007
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=0.006779424          lketa=-1.9430023e-008
+ dwg=0                     dwb=0                     pclm=0.2029311
+ lpclm=-1.4447311e-007     pdiblc1=0                 pdiblc2=0.0086712
+ lpdiblc2=-1.1183446e-008  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.01                pscbe1=3.877834e+008
+ pscbe2=1e-008             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=7.28
+ rdsw=250                  prwg=0                    prwb=0
+ wr=1                      alpha0=0                  alpha1=-0.03692708
+ lalpha1=7.8138254e-008    beta0=-0.02496+dbeta0n_na5
+ lbeta0=1.6848105e-005     agidl=1e-012              bgidl=1.698e+009
+ cgidl=0.25                egidl=0.2624              aigbacc=0.01213
+ bigbacc=0.006537          cigbacc=0.2809            nigbacc=4.05
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01
+ bigc=0.00144              cigc=1.52e-005            aigsd=0.008379
+ bigsd=0.0002699           cigsd=3.93e-020           nigc=1
+ poxedge=1                 pigcd=2.171               ntox=1
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na5
+ cgdo=cgon_na5             cgbo=0                    cgdl=cgln_na5
+ cgsl=cgln_na5             clc=1e-007                cle=0.6
+ cf=cfn_na5                ckappas=0.6               ckappad=0.6
+ acde=0.55                 moin=20                   noff=3
+ voffcv=-0.05              tvoff=-0.000592615        ltvoff=9.9101138e-009
+ wtvoff=0                  ptvoff=0                  kt1=-0.2428731
+ lkt1=1.2867041e-007       kt1l=0                    kt2=-0.0169393
+ lkt2=4.3153516e-009       ute=-1.2                  ua1=3.119898e-009
+ lua1=-3.5616846e-016      ub1=-4.35369e-018         lub1=2.3278587e-024
+ uc1=-4.3785e-011          luc1=1.1852022e-016       prt=0
+ at=-71602.68              lat=0.095885897           fnoimod=1
+ tnoimod=0                 em=1.192e+06              ef=1.00
+ noia=7.0e+39              noib=1.5e+25              noic=1e+6
+ lintnoi=-1e-7             jss=2.2e-06               jsd=2.2e-06
+ jsws=9.0e-12              jswd=9.0e-12              jswgs=1.9e-11
+ jswgd=1.9e-11             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=12.0                  bvd=12.0
+ xjbvs=1                   xjbvd=1                   jtsswgs=5e-012
+ jtsswgd=5e-012            njtsswg=19                xtsswgs=0.62
+ xtsswgd=0.62              tnjtsswg=1                vtsswgs=10.147
+ vtsswgd=10.147            pbs=0.568                 pbd=0.568
+ cjs=cjn_na5               cjd=cjn_na5               mjs=0.396
+ mjd=0.396                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_na5           cjswd=cjswn_na5           mjsws=0.101
+ mjswd=0.101               pbswgs=1.000              pbswgd=1.000
+ cjswgs=cjswgn_na5         cjswgd=cjswgn_na5         mjswgs=0.850
+ mjswgd=0.850              tpb=2.1e-03               tcj=2.0e-03
+ tpbsw=1.5e-03             tcjsw=5.0e-04             tpbswg=5.0e-04
+ tcjswg=1.0e-03            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   pu0=0+dpu0n_na5           wu0=0+dwu0n_na5
+ wvth0=0+dwvthn_na5        pvth0=0+dpvthn_na5        pvsat=0+dpvsatn_na5
+ rshg=8.23                 minr=1e-3
 
     4: type=n 
+ lmin=1e-005-dxln_na5      lmax=900.01e-6            wmin=1.2e-06
+ wmax=1e-005-dxwn_na5      version=4.5               gbmin=1.00e-12
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ geomod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na5             toxm=toxn_na5
+ dtox=0                    epsrox=3.9                wint=0
+ lint=9.9e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_na5        xw=1e-08+dxwn_na5         dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.089115588+dvthn_na5
+ wvth0=6.1217031e-008+dwvthn_na5                     k1=0.07
+ k2=0.007580945+dk2n_na5   wk2=-1.0735175e-008       k3=0
+ k3b=-7.7                  w0=0                      dvt0=0.1
+ dvt1=0.053                dvt2=-0.014               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.2106
+ minv=-0.3                 voffl=0                   dvtp0=2.721e-010
+ dvtp1=5                   lpe0=4.44089e-021         lpeb=1.177e-006
+ xj=1.5000001e-007         ngate=8e+019              ndep=1e+016
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5.0814775e-005
+ wcit=1.2689902e-010       voff=-0.0986165           wvoff=-1.9654635e-008
+ nfactor=1                 eta0=0.39538563           weta0=-3.5421011e-007
+ etab=0.012993408          wetab=-1.6170232e-008     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.067639063+du0n_na5   wu0=-7.9485656e-009+dwu0n_na5
+ ua=1.8195688e-009         wua=-4.0809519e-016       ub=5.7888825e-019
+ wub=2.1132862e-025        uc=-6.1871875e-012        wuc=-1.1940053e-017
+ vsat=130514.5             wvsat=-0.020865845        a0=1.5933055
+ wa0=-8.2588006e-007       ags=0.61317113            wags=-2.3864966e-007
+ a1=0                      a2=0.99                   b0=0
+ b1=0                      keta=-0.025010263         wketa=1.3255868e-008
+ dwg=0                     dwb=0                     pclm=1.4925
+ pdiblc1=0                 pdiblc2=0.00145475        wpdiblc2=-1.3488475e-009
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.01                pscbe1=3.877834e+008      pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=250
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=-0.00083375        walpha1=1.3350838e-008
+ beta0=6.6894+dbeta0n_na5  wbeta0=6.012006e-006      agidl=1e-012
+ bgidl=1.698e+009          cgidl=0.25                egidl=0.2624
+ aigbacc=0.01213           bigbacc=0.006537          cigbacc=0.2809
+ nigbacc=4.05              aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01                 bigc=0.00144              cigc=1.52e-005
+ aigsd=0.008379            bigsd=0.0002699           cigsd=3.93e-020
+ nigc=1                    poxedge=1                 pigcd=2.171
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na5             cgdo=cgon_na5             cgbo=0
+ cgdl=cgln_na5             cgsl=cgln_na5             clc=1e-007
+ cle=0.6                   cf=cfn_na5                ckappas=0.6
+ ckappad=0.6               acde=0.55                 moin=20
+ noff=3                    voffcv=-0.05              tvoff=0.0053534263
+ ltvoff=0                  wtvoff=-2.5367968e-009    ptvoff=0
+ kt1=-0.16801688           wkt1=-7.6388813e-009      kt1l=0
+ kt2=-0.012203125          wkt2=-1.5484219e-008      ute=-1.185
+ ua1=4.615905e-009         wua1=-1.8889371e-015      ub1=-6.03926e-018
+ wub1=3.5961926e-024       uc1=-6e-011               prt=0
+ at=-17475.875             wat=-0.00015140125        fnoimod=1
+ tnoimod=0                 em=1.192e+06              ef=1.00
+ noia=7.0e+39              noib=1.5e+25              noic=1e+6
+ lintnoi=-1e-7             jss=2.2e-06               jsd=2.2e-06
+ jsws=9.0e-12              jswd=9.0e-12              jswgs=1.9e-11
+ jswgd=1.9e-11             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=12.0                  bvd=12.0
+ xjbvs=1                   xjbvd=1                   jtsswgs=5e-012
+ jtsswgd=5e-012            njtsswg=19                xtsswgs=0.62
+ xtsswgd=0.62              tnjtsswg=1                vtsswgs=10.147
+ vtsswgd=10.147            pbs=0.568                 pbd=0.568
+ cjs=cjn_na5               cjd=cjn_na5               mjs=0.396
+ mjd=0.396                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_na5           cjswd=cjswn_na5           mjsws=0.101
+ mjswd=0.101               pbswgs=1.000              pbswgd=1.000
+ cjswgs=cjswgn_na5         cjswgd=cjswgn_na5         mjswgs=0.850
+ mjswgd=0.850              tpb=2.1e-03               tcj=2.0e-03
+ tpbsw=1.5e-03             tcjsw=5.0e-04             tpbswg=5.0e-04
+ tcjswg=1.0e-03            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   pu0=0+dpu0n_na5           lu0=0+dlu0n_na5
+ lvth0=0+dlvthn_na5        pvth0=0+dpvthn_na5        lvsat=0+dlvsatn_na5
+ pvsat=0+dpvsatn_na5       rshg=8.23                 minr=1e-3
 
     5: type=n 
+ lmin=2e-006-dxln_na5      lmax=1e-005-dxln_na5      wmin=1.2e-06
+ wmax=1e-005-dxwn_na5      version=4.5               gbmin=1.00e-12
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ geomod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na5             toxm=toxn_na5
+ dtox=0                    epsrox=3.9                wint=0
+ lint=9.9e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_na5        xw=1e-08+dxwn_na5         dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=-0.08822822+dvthn_na5
+ lvth0=-8.6713578e-009+dlvthn_na5                    wvth0=5.7438509e-008+dwvthn_na5
+ pvth0=3.6923721e-014+dpvthn_na5                     k1=0.07
+ k2=0.0088254306+dk2n_na5  lk2=-1.2161113e-008       wk2=-1.0978946e-008
+ pk2=2.3821371e-015        k3=0                      k3b=-7.7
+ w0=0                      dvt0=0.1                  dvt1=0.053
+ dvt2=-0.014               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2106               minv=-0.3
+ voffl=0                   dvtp0=2.721e-010          dvtp1=5
+ lpe0=4.44089e-021         lpeb=1.177e-006           xj=1.5000001e-007
+ ngate=8e+019              ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-2.6658887e-005       lcit=7.5707262e-010
+ wcit=2.2800453e-010       pcit=-9.8800297e-016      voff=-0.099226184
+ lvoff=5.9578349e-009      wvoff=-1.5684656e-008     pvoff=-3.8794634e-014
+ nfactor=1                 eta0=0.39074963           leta0=4.5302943e-008
+ weta0=-3.4860055e-007     peta0=-5.4816561e-014     etab=0.012993408
+ wetab=-1.6170232e-008     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.066495239+du0n_na5
+ lu0=1.1177441e-008+dlu0n_na5                        wu0=-7.7933883e-009+dwu0n_na5
+ pu0=-1.5163929e-015+dpu0n_na5                       ua=1.6276966e-009
+ lua=1.8749748e-015        wua=-3.7541344e-016       pua=-3.1936605e-022
+ ub=7.3378169e-019         lub=-1.5136187e-024       wub=1.5913721e-025
+ pub=5.1001448e-031        uc=-7.3447257e-012        luc=1.1311464e-017
+ wuc=-4.788634e-018        puc=-6.9883668e-023       vsat=137331.14
+ lvsat=-0.066612155+dlvsatn_na5                      wvsat=-0.024002927
+ pvsat=3.0655566e-008+dpvsatn_na5                    a0=3.0913367
+ la0=-1.4638761e-005       wa0=-1.9176822e-006       pa0=1.066909e-011
+ ags=0.6942579             lags=-7.9237997e-007      wags=-2.7334963e-007
+ pags=3.390881e-013        a1=0                      a2=0.99
+ b0=0                      b1=0                      keta=-0.02992351
+ lketa=4.8012256e-008      wketa=1.9200897e-008      pketa=-5.809483e-014
+ dwg=0                     dwb=0                     pclm=1.8161384
+ lpclm=-3.162594e-006      wpclm=-1.9959647e-007     ppclm=1.9504567e-012
+ pdiblc1=0                 pdiblc2=0.0012219535      lpdiblc2=2.2748874e-009
+ wpdiblc2=-1.3244581e-009  ppdiblc2=-2.3833288e-016  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.01
+ pscbe1=3.877834e+008      pscbe2=1e-008             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=7.28                  rdsw=250                  prwg=0
+ prwb=0                    wr=1                      alpha0=0
+ alpha1=-0.0017438077      lalpha1=8.8930835e-009    walpha1=7.6739079e-009
+ palpha1=5.5474956e-014    beta0=6.1801687+dbeta0n_na5
+ lbeta0=4.976208e-006      wbeta0=6.2470585e-006     pbeta0=-2.2969331e-012
+ agidl=1e-012              bgidl=1.698e+009          cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na5             cgdo=cgon_na5
+ cgbo=0                    cgdl=cgln_na5             cgsl=cgln_na5
+ clc=1e-007                cle=0.6                   cf=cfn_na5
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=20                   noff=3                    voffcv=-0.05
+ tvoff=0.0054347558        ltvoff=-7.9475226e-010    wtvoff=-3.129184e-009
+ ptvoff=5.7888076e-015     kt1=-0.16696085           lkt1=-1.0319515e-008
+ wkt1=-1.4928253e-008      pkt1=7.1231738e-014       kt1l=0
+ kt2=-0.01201315           lkt2=-1.8564358e-009      wkt2=-1.5714089e-008
+ pkt2=2.2462873e-015       ute=-1.1812207            lute=-3.6931747e-008
+ wute=-4.5730059e-009      pute=4.4687414e-014       ua1=4.9764051e-009
+ lua1=-3.5228071e-015      wua1=-2.1533178e-015      pua1=2.5835284e-021
+ ub1=-6.7026946e-018       lub1=6.4830828e-024       wub1=4.3837252e-024
+ pub1=-7.6957685e-030      uc1=-8.0937564e-011       luc1=2.0460188e-016
+ wuc1=2.5334453e-017       puc1=-2.4756827e-022      prt=0
+ at=-17378.415             lat=-0.00095237912        wat=-0.0011269759
+ pat=9.533315e-009         fnoimod=1                 tnoimod=0
+ em=1.192e+06              ef=1.00                   noia=7.0e+39
+ noib=1.5e+25              noic=1e+6                 lintnoi=-1e-7
+ jss=2.2e-06               jsd=2.2e-06               jsws=9.0e-12
+ jswd=9.0e-12              jswgs=1.9e-11             jswgd=1.9e-11
+ njs=1.02                  njd=1.02                  ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=12.0                  bvd=12.0                  xjbvs=1
+ xjbvd=1                   jtsswgs=5e-012            jtsswgd=5e-012
+ njtsswg=19                xtsswgs=0.62              xtsswgd=0.62
+ tnjtsswg=1                vtsswgs=10.147            vtsswgd=10.147
+ pbs=0.568                 pbd=0.568                 cjs=cjn_na5
+ cjd=cjn_na5               mjs=0.396                 mjd=0.396
+ pbsws=0.406               pbswd=0.406               cjsws=cjswn_na5
+ cjswd=cjswn_na5           mjsws=0.101               mjswd=0.101
+ pbswgs=1.000              pbswgd=1.000              cjswgs=cjswgn_na5
+ cjswgd=cjswgn_na5         mjswgs=0.850              mjswgd=0.850
+ tpb=2.1e-03               tcj=2.0e-03               tpbsw=1.5e-03
+ tcjsw=5.0e-04             tpbswg=5.0e-04            tcjswg=1.0e-03
+ xtis=3                    xtid=3                    dmcg=2e-007
+ dmci=2e-007               dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-3.1e-008
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ rshg=8.23                 minr=1e-3
 
     6: type=n 
+ lmin=1.6e-06              lmax=2e-006-dxln_na5      wmin=1.2e-06
+ wmax=1e-005-dxwn_na5      version=4.5               gbmin=1.00e-12
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ geomod=0                  diomod=1                  rdsmod=0
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na5             toxm=toxn_na5
+ dtox=0                    epsrox=3.9                wint=0
+ lint=9.9e-008             ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     wwc=0
+ xl=-3e-08+dxln_na5        xw=1e-08+dxwn_na5         dlc=1.26e-007
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=6.25e-009           vth0=0.011663494+dvthn_na5
+ lvth0=-1.8567948e-007+dlvthn_na5                    wvth0=-7.9031494e-008+dwvthn_na5
+ pvth0=2.7874857e-013+dpvthn_na5                     k1=0.07
+ k2=-0.019089125+dk2n_na5  lk2=3.730348e-008         wk2=-4.9136588e-009
+ pk2=-8.3655522e-015       k3=0                      k3b=-7.3698625
+ lk3b=-5.8500365e-007      wk3b=-3.3046764e-006      pk3b=5.8558865e-012
+ w0=0                      dvt0=0.1                  dvt1=0.053
+ dvt2=-0.014               dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.2106               minv=-0.3
+ voffl=0                   dvtp0=2.721e-010          dvtp1=5
+ lpe0=4.44089e-021         lpeb=1.177e-006           xj=1.5000001e-007
+ ngate=8e+019              ndep=1e+016               nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.0010079727         lcit=2.4959606e-009
+ wcit=1.1467341e-009       pcit=-2.6159918e-015      voff=-0.12626012
+ lvoff=5.386197e-008       wvoff=1.9205992e-008      pvoff=-1.0062086e-013
+ nfactor=1                 eta0=0.41631563           weta0=-3.7953541e-007
+ etab=0.012993408          wetab=-1.6170232e-008     ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.068990005+du0n_na5   lu0=6.7567162e-009+dlu0n_na5
+ wu0=2.0863368e-009+dwu0n_na5                        pu0=-1.9023266e-014+dpu0n_na5
+ ua=1.8782496e-009         lua=1.4309949e-015        wua=3.281223e-016
+ pua=-1.5660314e-021       ub=-1.0637404e-019        lub=-2.4862731e-026
+ wub=1.1798338e-024        pub=-1.29866e-030         uc=9.7354139e-012
+ luc=-1.8954544e-017       wuc=-5.7169371e-017       puc=2.2934998e-023
+ vsat=122654.08            lvsat=-0.04060442+dlvsatn_na5
+ wvsat=0.0066668302        pvsat=-2.3691244e-008+dpvsatn_na5
+ a0=-21.179995             la0=2.8370038e-005        wa0=2.9549116e-005
+ pa0=-4.5090075e-011       ags=0.56306934            lags=-5.5991383e-007
+ wags=-5.3595877e-007      pags=8.044315e-013        a1=0
+ a2=0.99                   b0=0                      b1=0
+ keta=0.0096441573         lketa=-2.2101651e-008     wketa=-2.867598e-008
+ pketa=2.6742997e-014      dwg=0                     dwb=0
+ pclm=0.09849699           lpclm=-1.1893352e-007     wpclm=1.0453854e-006
+ ppclm=-2.5565128e-013     pdiblc1=0                 pdiblc2=0.00911879
+ lpdiblc2=-1.1718307e-008  wpdiblc2=-4.4803759e-009  ppdiblc2=5.3539534e-015
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.01                pscbe1=3.877834e+008      pscbe2=1e-008
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=7.28                  rdsw=250
+ prwg=0                    prwb=0                    wr=1
+ alpha0=0                  alpha1=-0.034389667       lalpha1=6.6741547e-008
+ walpha1=-2.53995e-008     palpha1=1.1408104e-013    beta0=-1.4047876+dbeta0n_na5
+ lbeta0=1.8416751e-005     wbeta0=1.3812075e-005     pbeta0=-1.5702142e-011
+ agidl=1e-012              bgidl=1.698e+009          cgidl=0.25
+ egidl=0.2624              aigbacc=0.01213           bigbacc=0.006537
+ cigbacc=0.2809            nigbacc=4.05              aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01                 bigc=0.00144
+ cigc=1.52e-005            aigsd=0.008379            bigsd=0.0002699
+ cigsd=3.93e-020           nigc=1                    poxedge=1
+ pigcd=2.171               ntox=1                    xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na5             cgdo=cgon_na5
+ cgbo=0                    cgdl=cgln_na5             cgsl=cgln_na5
+ clc=1e-007                cle=0.6                   cf=cfn_na5
+ ckappas=0.6               ckappad=0.6               acde=0.55
+ moin=20                   noff=3                    voffcv=-0.05
+ tvoff=-0.0013753496       ltvoff=1.1272754e-008     wtvoff=7.835173e-009
+ ptvoff=-1.3640033e-014    kt1=-0.26334293           lkt1=1.6046954e-007
+ wkt1=2.0490301e-007       pkt1=-3.1830926e-013      kt1l=0
+ kt2=-0.012057954          lkt2=-1.7770436e-009      wkt2=-4.8862276e-008
+ pkt2=6.0984876e-014       ute=-1.2020625            wute=2.0645625e-008
+ ua1=3.3940483e-009        lua1=-7.1887072e-016      wua1=-2.744244e-015
+ pua1=3.6306497e-021       ub1=-4.4589707e-018       lub1=2.5072041e-024
+ wub1=1.0538601e-024       pub1=-1.7952475e-030      uc1=-4.1555438e-011
+ luc1=1.3481675e-016       wuc1=-2.2317921e-017      puc1=-1.6312827e-022
+ prt=0                     at=-77075.593             lat=0.10483102
+ wat=0.054783861           pat=-8.9540688e-008       fnoimod=1
+ tnoimod=0                 em=1.192e+06              ef=1.00
+ noia=7.0e+39              noib=1.5e+25              noic=1e+6
+ lintnoi=-1e-7             jss=2.2e-06               jsd=2.2e-06
+ jsws=9.0e-12              jswd=9.0e-12              jswgs=1.9e-11
+ jswgd=1.9e-11             njs=1.02                  njd=1.02
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=12.0                  bvd=12.0
+ xjbvs=1                   xjbvd=1                   jtsswgs=5e-012
+ jtsswgd=5e-012            njtsswg=19                xtsswgs=0.62
+ xtsswgd=0.62              tnjtsswg=1                vtsswgs=10.147
+ vtsswgd=10.147            pbs=0.568                 pbd=0.568
+ cjs=cjn_na5               cjd=cjn_na5               mjs=0.396
+ mjd=0.396                 pbsws=0.406               pbswd=0.406
+ cjsws=cjswn_na5           cjswd=cjswn_na5           mjsws=0.101
+ mjswd=0.101               pbswgs=1.000              pbswgd=1.000
+ cjswgs=cjswgn_na5         cjswgd=cjswgn_na5         mjswgs=0.850
+ mjswgd=0.850              tpb=2.1e-03               tcj=2.0e-03
+ tpbsw=1.5e-03             tcjsw=5.0e-04             tpbswg=5.0e-04
+ tcjswg=1.0e-03            xtis=3                    xtid=3
+ dmcg=2e-007               dmci=2e-007               dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-3.1e-008             rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   rshg=8.23                 minr=1e-3
 
 
     } 
endsection mosna5
 
// *********************************************************************************************
// **********************************
//                                  *
//     1.8V PNP AND NPN bipolar     *
//                                  *
// **********************************
// *****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_bip
include "cmn018_gp2a_5v_v1d4.scs" section=setup_bip
parameters par_bjtp1=0
parameters par_bjtp2=0
parameters par_bjtn1=0
parameters par_bjtn2=0
parameters isa=1
parameters bfa=1
parameters nfa=1
parameters rba=1
parameters rea=1
parameters rca=1
parameters rbma=1
parameters cjea=1
parameters cjca=1
include "cmn018_gp2a_5v_v1d4.scs" section=bip
endsection tt_bip
 
// *****************************  LIBRARY OF SS CORNER CASE  ******************************

section ss_bip
include "cmn018_gp2a_5v_v1d4.scs" section=setup_bip
parameters par_bjtp1=0
parameters par_bjtp2=0
parameters par_bjtn1=0
parameters par_bjtn2=0
parameters isa=0.7
parameters bfa=0.85
parameters nfa=0.9975
parameters rba=1.2
parameters rea=1.2
parameters rca=1.2
parameters rbma=1.2
parameters cjea=1.07
parameters cjca=1.07
include "cmn018_gp2a_5v_v1d4.scs" section=bip
endsection ss_bip
 
// *****************************  LIBRARY OF FF CORNER CASE  ******************************

section ff_bip
include "cmn018_gp2a_5v_v1d4.scs" section=setup_bip
parameters par_bjtp1=0
parameters par_bjtp2=0
parameters par_bjtn1=0
parameters par_bjtn2=0
parameters isa=1.3
parameters bfa=1.15
parameters nfa=1.0025
parameters rba=0.8
parameters rea=0.8
parameters rca=0.8
parameters rbma=0.8
parameters cjea=0.93
parameters cjca=0.93
include "cmn018_gp2a_5v_v1d4.scs" section=bip
endsection ff_bip
 

section mc_bip
include "cmn018_gp2a_5v_v1d4.scs" section=setup_bip
parameters par_bjtp1=0
parameters par_bjtp2=0
parameters par_bjtn1=0
parameters par_bjtn2=0
parameters par1mc_bip=0
parameters a1_bip=par1mc_bip * 3 / 3
parameters isa=1 + ( - 0.1) * a1_bip
parameters bfa=1 + ( - 0.05) * a1_bip
parameters nfa=1 + ( - 0.00083333) * a1_bip
parameters rba=1 + (0.066667) * a1_bip
parameters rea=1 + (0.066667) * a1_bip
parameters rca=1 + (0.066667) * a1_bip
parameters rbma=1 + (0.066667) * a1_bip
parameters cjea=1 + (0.023333) * a1_bip
parameters cjca=1 + (0.023333) * a1_bip

statistics {
    process {
        vary par1mc_bip dist=gauss std=1/1
        }
    }
include "cmn018_gp2a_5v_v1d4.scs" section=bip
endsection mc_bip
 
// ******************************************************************************************
//                                                                            
//                *
//                    MODELS OF VERTICAL BIPOLAR 1.8V PNP AND NPN BIPOLAR     
//                *
//                                                                            
//                *
// ******************************************************************************************

section bip
// 
// 
model pnp10 bjt type=pnp 
+ is=1.15e-017*isa          bf=2.6985*bfa             nf=1.0007*nfa
+ vaf=405.88                ikf=0.003612              ise=8.4643e-017*isa
+ ne=1.5023                 br=0.00896                nr=0.98897
+ var=27.146                ikr=0.01                  isc=1.15e-017*isa
+ nc=1                      rb=169.86*rba             irb=0.001
+ rbm=0.1*rbma              re=29.705*rea             rc=78.36*rca
+ nkf=0.71005               tnom=25                   xtb=0
+ xti=2.8858                eg=1.18                   tlev=1
+ tlevc=1                   tbf1=0.00482              tbf2=5e-007
+ tbr1=0.0002945            tikf1=-0.0027588          tikr1=0.005
+ tirb1=0.005               tne1=0.00044              tnr1=-0.00024
+ trb1=0.0049               trb2=-7e-005              trc1=0.0072035
+ tre1=-0.003489            trm1=0.005                cje=1.174e-13*cjea
+ vje=0.860                 mje=0.440                 cjc=6.838e-14*cjca
+ vjc=0.5846489             mjc=0.3883243             fc=0
+ ctc=2.8425e-3             cte=9.18e-04              tvjc=2.819e-3
+ tvje=1.61e-03             rbmod=spice               minr=1e-3
// 
// 
model pnp5 bjt type=pnp 
+ is=3.27e-018*isa          bf=2.72*bfa               nf=1.001*nfa
+ vaf=429.66                ikf=0.0011248             ise=6.254e-018*isa
+ ne=1.3201                 br=0.00386                nr=0.97829
+ var=26.48624              ikr=0.01                  isc=3.27e-018*isa
+ nc=1.12729                rb=108.26*rba             irb=0.001
+ rbm=0.1*rbma              re=22.585*rea             rc=91.045*rca
+ nkf=0.54912               tnom=25                   xtb=0
+ xti=2.25                  eg=1.2015                 tlev=1
+ tlevc=1                   tbf1=0.005105             tbf2=1.6946e-006
+ tbr1=0.0002               tikf1=-0.0030433          tikr1=0.01
+ tirb1=0.00227             tne1=-0.0001205           tnf1=2e-005
+ tnr1=-0.00027683          trb1=-0.00109             trc1=-0.0034017
+ tre1=0.000788             trm1=0.01                 cje=3.069e-14*cjea
+ vje=0.860                 mje=0.440                 cjc=3.965e-14*cjca
+ vjc=0.5846489             mjc=0.3883243             fc=0
+ ctc=2.8425e-3             cte=9.18e-04              tvjc=2.819e-3
+ tvje=1.61e-03             rbmod=spice               minr=1e-3
// 
// 
model pnp2 bjt type=pnp 
+ is=7.35e-019*isa          bf=2.74*bfa               nf=1.0015*nfa
+ vaf=239.32                ikf=0.00031594            ise=2.5904e-017*isa
+ ne=1.5736                 br=0.0012422              nr=0.98411
+ var=21                    ikr=0.01                  isc=7.35e-019*isa
+ nc=1.7613                 rb=110.44*rba             irb=0.001
+ rbm=0.1*rbma              re=40*rea                 rc=83.521*rca
+ nkf=0.44174               tnom=25                   xtb=0
+ xti=1.24                  eg=1.23                   tlev=1
+ tlevc=1                   tbf1=0.0056903            tbf2=1.826e-006
+ tbr1=4.1093e-005          tikf1=-0.008              tikf2=4.3205e-005
+ tikr1=0.005               tirb1=-0.005              tnc1=-0.0005
+ tne1=0.00018367           tnf1=4.5e-005             tnf2=-1.5e-007
+ tnr1=-0.00014576          trb1=-0.002               trb2=-1.1491e-005
+ trc1=0.00238              tre1=0.00095908           trm1=0.005
+ tvaf1=-1e-007             cje=5.556e-15*cjea        vje=0.860
+ mje=0.440                 cjc=2.563e-14*cjca        vjc=0.5846489
+ mjc=0.3883243             fc=0                      ctc=2.8425e-3
+ cte=9.18e-04              tvjc=2.819e-3             tvje=1.61e-03
+ rbmod=spice               minr=1e-3
// 
// 
model npn10 bjt type=npn 
+ is=3.2088e-017*isa        bf=12.07*bfa              nf=1.005*nfa
+ vaf=41.931                ikf=0.012582              ise=3.2088e-017*isa
+ ne=1.254                  br=4.48                   nr=1
+ var=31.465                ikr=0.00066882            isc=3.2088e-017*isa
+ nc=1.0124                 rb=34.8*rba               irb=0.001
+ rbm=1.5*rbma              re=7.75*rea               rc=8.52*rca
+ nkf=0.20138               tnom=25                   xtb=0
+ xti=3                     eg=1.17                   tlev=0
+ tlevc=1                   tbf1=0.005368             tbr1=0.0037497
+ tikf1=-0.0042134          tikr1=0.012               tne1=0.0005
+ tnf1=-0.0001342           trb1=0.00035              trc1=0.0033
+ tre1=-0.0016              cje=1.028e-13*cjea        vje=0.6882682
+ mje=0.359                 cjc=1.389e-13*cjca        vjc=0.75
+ mjc=0.37                  fc=0                      ctc=1.100e-03
+ cte=9.05e-4               tvjc=1.850e-03            tvje=1.49e-3
+ rbmod=spice               minr=1e-3
// 
// 
model npn5 bjt type=npn 
+ is=9.3566e-018*isa        bf=12.54*bfa              nf=1.005*nfa
+ vaf=46.409                ikf=0.0033855             ise=9.3566e-018*isa
+ ne=1.24                   br=0.73111                nr=1
+ var=28.111                ikr=0.00224               isc=9.3566e-018*isa
+ nc=1.0347                 rb=33.3*rba               irb=0.001
+ rbm=1.5*rbma              re=11.137*rea             rc=10*rca
+ nkf=0.18761               tnom=25                   xtb=0
+ xti=3                     eg=1.17                   tlev=0
+ tlevc=1                   tbf1=0.0055872            tbr1=0.0012535
+ tikf1=-0.0056376          tikr1=0.00015             tne1=0.00046
+ tnf1=-0.00012289          trb1=0.0005               trc1=0.001
+ tre1=-0.0001              cje=2.690e-14*cjea        vje=0.6882682
+ mje=0.359                 cjc=6.989e-14*cjca        vjc=0.75
+ mjc=0.37                  fc=0                      ctc=1.100e-03
+ cte=9.05e-4               tvjc=1.850e-03            tvje=1.49e-3
+ rbmod=spice               minr=1e-3
// 
// 
model npn2 bjt type=npn 
+ is=2.0522e-018*isa        bf=13.393*bfa             nf=1.005*nfa
+ vaf=75.421                ikf=0.00056692            ise=2.0522e-018*isa
+ ne=1.2056                 br=0.2366                 nr=1
+ var=32.37                 ikr=0.0037105             isc=2.0522e-018*isa
+ nc=1.0205                 rb=58.2*rba               irb=0.001
+ rbm=2*rbma                re=17.916*rea             rc=7.3807*rca
+ nkf=0.20012               tnom=25                   xtb=0
+ xti=3                     eg=1.17                   tlev=0
+ tlevc=1                   tbf1=0.0068318            tbr1=0.001106
+ tikf1=-0.0054391          tne1=0.0002               tnf1=-0.00011466
+ trb1=1.98e-005            trc1=0.001                tre1=0.0004884
+ cje=4.872e-15*cjea        vje=0.6882682             mje=0.359
+ cjc=3.965e-14*cjca        vjc=0.75                  mjc=0.37
+ fc=0                      ctc=1.100e-03             cte=9.05e-4
+ tvjc=1.850e-03            tvje=1.49e-3              rbmod=spice
+ minr=1e-3
// 
// ************************************************
//                                                *
//         1.8V bipolar Mismatch Model            *
//                                                *
// ************************************************
// 
subckt pnp10_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis10=1 + 0.31e-2 * (1 / sqrt(multi 
+ * 10e-6 * 10e-6 * 1e12)) * par_bjtp1 * mismatchflag bfmis10=1 + 1.1405e-2 * (1 
+ / sqrt(multi * 10e-6 * 10e-6 * 1e12)) * par_bjtp2 * mismatchflag 
qin ( c b e ) pnp10 m=multi
model pnp10 bjt type=pnp 
+ is=1.15e-017*isa*ismis10  bf=2.6985*bfa*bfmis10     nf=1.0007*nfa
+ vaf=405.88                ikf=0.003612              ise=8.4643e-017*isa/bfmis10
+ ne=1.5023                 br=0.00896                nr=0.98897
+ var=27.146                ikr=0.01                  isc=1.15e-017*isa
+ nc=1                      rb=169.86*rba             irb=0.001
+ rbm=0.1*rbma              re=29.705*rea             rc=78.36*rca
+ nkf=0.71005               tnom=25                   xtb=0
+ xti=2.8858                eg=1.18                   tlev=1
+ tlevc=1                   tbf1=0.00482              tbf2=5e-007
+ tbr1=0.0002945            tikf1=-0.0027588          tikr1=0.005
+ tirb1=0.005               tne1=0.00044              tnr1=-0.00024
+ trb1=0.0049               trb2=-7e-005              trc1=0.0072035
+ tre1=-0.003489            trm1=0.005                cje=1.174e-13*cjea
+ vje=0.860                 mje=0.440                 cjc=6.838e-14*cjca
+ vjc=0.5846489             mjc=0.3883243             fc=0
+ ctc=2.8425e-3             cte=9.18e-04              tvjc=2.819e-3
+ tvje=1.61e-03             rbmod=spice               minr=1e-3
// 
ends pnp10_mis
// 
// 
subckt pnp5_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis5=1 + 0.31e-2 * (1 / sqrt(multi 
+ * 5e-6 * 5e-6 * 1e12)) * par_bjtp1 * mismatchflag bfmis5=1 + 1.1405e-2 * (1 / 
+ sqrt(multi * 5e-6 * 5e-6 * 1e12)) * par_bjtp2 * mismatchflag 
qin ( c b e ) pnp5 m=multi
model pnp5 bjt type=pnp 
+ is=3.27e-018*isa*ismis5   bf=2.72*bfa*bfmis5        nf=1.001*nfa
+ vaf=429.66                ikf=0.0011248             ise=6.254e-018*isa/bfmis5
+ ne=1.3201                 br=0.00386                nr=0.97829
+ var=26.48624              ikr=0.01                  isc=3.27e-018*isa
+ nc=1.12729                rb=108.26*rba             irb=0.001
+ rbm=0.1*rbma              re=22.585*rea             rc=91.045*rca
+ nkf=0.54912               tnom=25                   xtb=0
+ xti=2.25                  eg=1.2015                 tlev=1
+ tlevc=1                   tbf1=0.005105             tbf2=1.6946e-006
+ tbr1=0.0002               tikf1=-0.0030433          tikr1=0.01
+ tirb1=0.00227             tne1=-0.0001205           tnf1=2e-005
+ tnr1=-0.00027683          trb1=-0.00109             trc1=-0.0034017
+ tre1=0.000788             trm1=0.01                 cje=3.069e-14*cjea
+ vje=0.860                 mje=0.440                 cjc=3.965e-14*cjca
+ vjc=0.5846489             mjc=0.3883243             fc=0
+ ctc=2.8425e-3             cte=9.18e-04              tvjc=2.819e-3
+ tvje=1.61e-03             rbmod=spice               minr=1e-3
// 
ends pnp5_mis
// 
// 
subckt pnp2_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis2=1 + 0.31e-2 * (1 / sqrt(multi 
+ * 2e-6 * 2e-6 * 1e12)) * par_bjtp1 * mismatchflag bfmis2=1 + 1.1405e-2 * (1 / 
+ sqrt(multi * 2e-6 * 2e-6 * 1e12)) * par_bjtp2 * mismatchflag 
qin ( c b e ) pnp2 m=multi
model pnp2 bjt type=pnp 
+ is=7.35e-019*isa*ismis2   bf=2.74*bfa*bfmis2        nf=1.0015*nfa
+ vaf=239.32                ikf=0.00031594            ise=2.5904e-017*isa/bfmis2
+ ne=1.5736                 br=0.0012422              nr=0.98411
+ var=21                    ikr=0.01                  isc=7.35e-019*isa
+ nc=1.7613                 rb=110.44*rba             irb=0.001
+ rbm=0.1*rbma              re=40*rea                 rc=83.521*rca
+ nkf=0.44174               tnom=25                   xtb=0
+ xti=1.24                  eg=1.23                   tlev=1
+ tlevc=1                   tbf1=0.0056903            tbf2=1.826e-006
+ tbr1=4.1093e-005          tikf1=-0.008              tikf2=4.3205e-005
+ tikr1=0.005               tirb1=-0.005              tnc1=-0.0005
+ tne1=0.00018367           tnf1=4.5e-005             tnf2=-1.5e-007
+ tnr1=-0.00014576          trb1=-0.002               trb2=-1.1491e-005
+ trc1=0.00238              tre1=0.00095908           trm1=0.005
+ tvaf1=-1e-007             cje=5.556e-15*cjea        vje=0.860
+ mje=0.440                 cjc=2.563e-14*cjca        vjc=0.5846489
+ mjc=0.3883243             fc=0                      ctc=2.8425e-3
+ cte=9.18e-04              tvjc=2.819e-3             tvje=1.61e-03
+ rbmod=spice               minr=1e-3
// 
ends pnp2_mis
// 
// 
subckt npn10_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis10=1 + 6.314e-3 * (1 / sqrt(multi 
+ * 10e-6 * 10e-6 * 1e12)) * par_bjtn1 * mismatchflag bfmis10=1 + 4.011e-2 * (1 
+ / sqrt(multi * 10e-6 * 10e-6 * 1e12)) * par_bjtn2 * mismatchflag 
qin ( c b e ) npn10 m=multi
model npn10 bjt type=npn 
+ is=3.2088e-017*isa*ismis10                          bf=12.07*bfa*bfmis10
+ nf=1.005*nfa              vaf=41.931                ikf=0.012582
+ ise=3.2088e-017*isa/bfmis10                         ne=1.254
+ br=4.48                   nr=1                      var=31.465
+ ikr=0.00066882            isc=3.2088e-017*isa       nc=1.0124
+ rb=34.8*rba               irb=0.001                 rbm=1.5*rbma
+ re=7.75*rea               rc=8.52*rca               nkf=0.20138
+ tnom=25                   xtb=0                     xti=3
+ eg=1.17                   tlev=0                    tlevc=1
+ tbf1=0.005368             tbr1=0.0037497            tikf1=-0.0042134
+ tikr1=0.012               tne1=0.0005               tnf1=-0.0001342
+ trb1=0.00035              trc1=0.0033               tre1=-0.0016
+ cje=1.028e-13*cjea        vje=0.6882682             mje=0.359
+ cjc=1.389e-13*cjca        vjc=0.75                  mjc=0.37
+ fc=0                      ctc=1.100e-03             cte=9.05e-4
+ tvjc=1.850e-03            tvje=1.49e-3              rbmod=spice
+ minr=1e-3
ends npn10_mis
// 
subckt npn5_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis5=1 + 6.314e-3 * (1 / sqrt(multi 
+ * 5e-6 * 5e-6 * 1e12)) * par_bjtn1 * mismatchflag bfmis5=1 + 4.011e-2 * (1 / sqrt(multi 
+ * 5e-6 * 5e-6 * 1e12)) * par_bjtn2 * mismatchflag 
qin ( c b e ) npn5 m=multi
model npn5 bjt type=npn 
+ is=9.3566e-018*isa*ismis5 bf=12.54*bfa*bfmis5       nf=1.005*nfa
+ vaf=46.409                ikf=0.0033855             ise=9.3566e-018*isa/bfmis5
+ ne=1.24                   br=0.73111                nr=1
+ var=28.111                ikr=0.00224               isc=9.3566e-018*isa
+ nc=1.0347                 rb=33.3*rba               irb=0.001
+ rbm=1.5*rbma              re=11.137*rea             rc=10*rca
+ nkf=0.18761               tnom=25                   xtb=0
+ xti=3                     eg=1.17                   tlev=0
+ tlevc=1                   tbf1=0.0055872            tbr1=0.0012535
+ tikf1=-0.0056376          tikr1=0.00015             tne1=0.00046
+ tnf1=-0.00012289          trb1=0.0005               trc1=0.001
+ tre1=-0.0001              cje=2.690e-14*cjea        vje=0.6882682
+ mje=0.359                 cjc=6.989e-14*cjca        vjc=0.75
+ mjc=0.37                  fc=0                      ctc=1.100e-03
+ cte=9.05e-4               tvjc=1.850e-03            tvje=1.49e-3
+ rbmod=spice               minr=1e-3
ends npn5_mis
// 
subckt npn2_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip multi=1 ismis2=1 + 6.314e-3 * (1 / sqrt(multi 
+ * 2e-6 * 2e-6 * 1e12)) * par_bjtn1 * mismatchflag bfmis2=1 + 4.011e-2 * (1 / sqrt(multi 
+ * 2e-6 * 2e-6 * 1e12)) * par_bjtn2 * mismatchflag 
qin ( c b e ) npn2 m=multi
model npn2 bjt type=npn 
+ is=2.0522e-018*isa*ismis2 bf=13.393*bfa*bfmis2      nf=1.005*nfa
+ vaf=75.421                ikf=0.00056692            ise=2.0522e-018*isa/bfmis2
+ ne=1.2056                 br=0.2366                 nr=1
+ var=32.37                 ikr=0.0037105             isc=2.0522e-018*isa
+ nc=1.0205                 rb=58.2*rba               irb=0.001
+ rbm=2*rbma                re=17.916*rea             rc=7.3807*rca
+ nkf=0.20012               tnom=25                   xtb=0
+ xti=3                     eg=1.17                   tlev=0
+ tlevc=1                   tbf1=0.0068318            tbr1=0.001106
+ tikf1=-0.0054391          tne1=0.0002               tnf1=-0.00011466
+ trb1=1.98e-005            trc1=0.001                tre1=0.0004884
+ cje=4.872e-15*cjea        vje=0.6882682             mje=0.359
+ cjc=3.965e-14*cjca        vjc=0.75                  mjc=0.37
+ fc=0                      ctc=1.100e-03             cte=9.05e-4
+ tvjc=1.850e-03            tvje=1.49e-3              rbmod=spice
+ minr=1e-3
ends npn2_mis
// 
// 
endsection bip
// *******************************************************************
//                                                                   *
//  5V PNP AND NPN bipolar w/i RPO protection around emitter edge    *
//                                                                   *
// *******************************************************************
// *****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_bip5_rpo
include "cmn018_gp2a_5v_v1d4.scs" section=setup_bip5_rpo
parameters par5_rpo_bjtp1=0
parameters par5_rpo_bjtp2=0
parameters par5_rpo_bjtn1=0
parameters par5_rpo_bjtn2=0
parameters isa5_rpo=1
parameters bfa5_rpo=1
parameters nfa5_rpo=1
parameters rba5_rpo=1
parameters rea5_rpo=1
parameters rca5_rpo=1
parameters rbma5_rpo=1
parameters cjea5_rpo=1
parameters cjca5_rpo=1
include "cmn018_gp2a_5v_v1d4.scs" section=bip5_rpo
endsection tt_bip5_rpo
 
// *****************************  LIBRARY OF SS CORNER CASE  ******************************

section ss_bip5_rpo
include "cmn018_gp2a_5v_v1d4.scs" section=setup_bip5_rpo
parameters par5_rpo_bjtp1=0
parameters par5_rpo_bjtp2=0
parameters par5_rpo_bjtn1=0
parameters par5_rpo_bjtn2=0
parameters isa5_rpo=0.7
parameters bfa5_rpo=0.85
parameters nfa5_rpo=0.9975
parameters rba5_rpo=1.2
parameters rea5_rpo=1.2
parameters rca5_rpo=1.2
parameters rbma5_rpo=1.2
parameters cjea5_rpo=1.07
parameters cjca5_rpo=1.07
include "cmn018_gp2a_5v_v1d4.scs" section=bip5_rpo
endsection ss_bip5_rpo
 
// *****************************  LIBRARY OF FF CORNER CASE  ******************************

section ff_bip5_rpo
include "cmn018_gp2a_5v_v1d4.scs" section=setup_bip5_rpo
parameters par5_rpo_bjtp1=0
parameters par5_rpo_bjtp2=0
parameters par5_rpo_bjtn1=0
parameters par5_rpo_bjtn2=0
parameters isa5_rpo=1.3
parameters bfa5_rpo=1.15
parameters nfa5_rpo=1.0025
parameters rba5_rpo=0.8
parameters rea5_rpo=0.8
parameters rca5_rpo=0.8
parameters rbma5_rpo=0.8
parameters cjea5_rpo=0.93
parameters cjca5_rpo=0.93
include "cmn018_gp2a_5v_v1d4.scs" section=bip5_rpo
endsection ff_bip5_rpo
 

section mc_bip5_rpo
include "cmn018_gp2a_5v_v1d4.scs" section=setup_bip5_rpo
parameters par5_rpo_bjtp1=0
parameters par5_rpo_bjtp2=0
parameters par5_rpo_bjtn1=0
parameters par5_rpo_bjtn2=0
parameters par1mc_bip5_rpo=0
parameters a1_bip5_rpo=par1mc_bip5_rpo * 3 / 3
parameters isa5_rpo=1 + ( - 0.1) * a1_bip5_rpo
parameters bfa5_rpo=1 + ( - 0.05) * a1_bip5_rpo
parameters nfa5_rpo=1 + ( - 0.00083333) * a1_bip5_rpo
parameters rba5_rpo=1 + (0.066667) * a1_bip5_rpo
parameters rea5_rpo=1 + (0.066667) * a1_bip5_rpo
parameters rca5_rpo=1 + (0.066667) * a1_bip5_rpo
parameters rbma5_rpo=1 + (0.066667) * a1_bip5_rpo
parameters cjea5_rpo=1 + (0.023333) * a1_bip5_rpo
parameters cjca5_rpo=1 + (0.023333) * a1_bip5_rpo

statistics {
    process {
        vary par1mc_bip5_rpo dist=gauss std=1/1
        }
    }
include "cmn018_gp2a_5v_v1d4.scs" section=bip5_rpo
endsection mc_bip5_rpo
 
// ******************************************************************************************
//                                                                            
//                *
//         MODELS OF 5V PNP AND NPN BIPOLA W/I RPO PROTECTION AROUND EMITTER EDGE 
//            *
//                                                                            
//                *
// ******************************************************************************************

section bip5_rpo
// 
// 
model pnp10_5_rpo bjt type=pnp 
+ is=1.27e-017*isa5_rpo     bf=2.96*bfa5_rpo          nf=1.002*nfa5_rpo
+ vaf=610.81                ikf=0.0029097             ise=4.2367e-016*isa5_rpo
+ ne=1.495                  br=0.0379                 nr=0.99928
+ var=24.184                ikr=0.01                  isc=3.4782e-015*isa5_rpo
+ nc=1.066                  rb=10.31*rba5_rpo         irb=0.001
+ rbm=0.1*rbma5_rpo         re=4.92*rea5_rpo          rc=14.687*rca5_rpo
+ nkf=0.57044               tnom=25                   xtb=0
+ xti=3.4659                eg=1.1578                 tlev=1
+ tlevc=1                   tbf1=0.0050748            tbf2=2.8e-006
+ tikf1=-0.003381           tikr1=0.00514             tnc1=2.694e-005
+ tnc2=8e-007               tne2=-4e-007              tnf1=-4.08e-005
+ tnf2=1e-007               tnr1=3.7107e-005          tvar1=0.00138
+ cje=1.300e-13*cjea5_rpo   vje=0.822                 mje=0.367
+ cjc=6.150e-14*cjca5_rpo   vjc=0.567                 mjc=0.354
+ fc=0                      ctc=0.0026                cte=0.000954
+ tvjc=0.00255              tvje=0.00165              rbmod=spice
+ minr=1e-3
// 
// 
model pnp5_5_rpo bjt type=pnp 
+ is=3.43e-018*isa5_rpo     bf=3.104*bfa5_rpo         nf=1.002*nfa5_rpo
+ vaf=581.99                ikf=0.001697              ise=1.6345e-016*isa5_rpo
+ ne=1.495                  br=0.5                    nr=1.0144
+ var=22.39                 ikr=0.01                  isc=3.1504e-015*isa5_rpo
+ nc=1.082                  rb=20*rba5_rpo            irb=0.001
+ rbm=0.1*rbma5_rpo         re=7.325*rea5_rpo         rc=5*rca5_rpo
+ nkf=0.53564               tnom=25                   xtb=0
+ xti=1.93                  eg=1.206                  tlev=1
+ tlevc=1                   tbf1=0.0054742            tbf2=5.28e-006
+ tbr1=0.003545             tikf1=-0.0024519          tikr1=0.00534
+ tnc1=-0.00019674          tnc2=1.6e-007             tne1=-0.00029
+ tne2=-1.4e-006            tnf1=-7.5e-007            tnf2=-1.5e-007
+ tnr1=-7.5409e-005         cje=3.448e-14*cjea5_rpo   vje=0.822
+ mje=0.367                 cjc=3.557e-14*cjca5_rpo   vjc=0.567
+ mjc=0.354                 fc=0                      ctc=0.0026
+ cte=0.000954              tvjc=0.00255              tvje=0.00165
+ rbmod=spice               minr=1e-3
// 
// 
model pnp2_5_rpo bjt type=pnp 
+ is=7.18e-019*isa5_rpo     bf=3.8*bfa5_rpo           nf=1.002*nfa5_rpo
+ vaf=300                   ikf=0.00050879            ise=1.5204e-016*isa5_rpo
+ ne=1.524                  br=0.58612                nr=1.0084
+ var=19.037                ikr=0.03634               isc=1.6129e-015*isa5_rpo
+ nc=1.0595                 rb=36*rba5_rpo            irb=0.001
+ rbm=0.1*rbma5_rpo         re=22.976*rea5_rpo        rc=20.8*rca5_rpo
+ nkf=0.48338               tnom=25                   xtb=0
+ xti=3.0048                eg=1.1546                 tlev=1
+ tlevc=1                   tbf1=0.00633              tbf2=8.611e-006
+ tikf1=-0.0040544          tikr1=0.00402             tnc1=-0.000395
+ tnc2=3.3e-007             tne1=-5e-005              tne2=1.2e-006
+ tnf1=-0.00013             tnf2=-2e-007              tnr1=-0.000336
+ tre1=-0.002               tvaf1=-0.005699           cje=6.472e-15*cjea5_rpo
+ vje=0.822                 mje=0.367                 cjc=2.294e-14*cjca5_rpo
+ vjc=0.567                 mjc=0.354                 fc=0
+ ctc=0.0026                cte=0.000954              tvjc=0.00255
+ tvje=0.00165              rbmod=spice               minr=1e-3
// 
// 
model npn10_5_rpo bjt type=npn 
+ is=2.35e-017*isa5_rpo     bf=10*bfa5_rpo            nf=1.001*nfa5_rpo
+ vaf=90.842                ikf=0.093495              ise=2.2081e-016*isa5_rpo
+ ne=1.4567                 br=0.752                  nr=1
+ var=26.893                ikr=0.025284              isc=1.0646e-015*isa5_rpo
+ nc=1.9                    rb=4.52*rba5_rpo          irb=0.001
+ rbm=0.1*rbma5_rpo         re=8.5*rea5_rpo           rc=9.1*rca5_rpo
+ nkf=0.8989                tnom=25                   xtb=0
+ xti=3.2298                eg=1.1722                 tlev=1
+ tlevc=1                   tbf1=0.00533              tbf2=-2.1e-006
+ tbr1=0.00097267           tbr2=-4.14e-006           tikf1=-0.0050686
+ tikr1=0.0048388           tne1=0.00038871           tnf1=-3.88e-005
+ tnf2=3e-007               tvaf1=-0.00303            tvar1=3.9259e-005
+ cje=1.223e-13*cjea5_rpo   vje=0.726                 mje=0.322
+ cjc=1.352e-13*cjca5_rpo   vjc=0.697                 mjc=0.348
+ fc=0                      ctc=0.0015                cte=0.00099
+ tvjc=0.00211              tvje=0.00171              rbmod=spice
+ minr=1e-3
// 
// 
model npn5_5_rpo bjt type=npn 
+ is=6.4e-018*isa5_rpo      bf=11.28*bfa5_rpo         nf=1.001*nfa5_rpo
+ vaf=80.393                ikf=0.1                   ise=7.4429e-017*isa5_rpo
+ ne=1.415                  br=0.36988                nr=1.0021
+ var=25.604                ikr=1                     isc=3.6669e-016*isa5_rpo
+ nc=1.84                   rb=5*rba5_rpo             irb=0.001
+ rbm=0.1*rbma5_rpo         re=17*rea5_rpo            rc=10.863*rca5_rpo
+ nkf=0.95                  tnom=25                   xtb=0
+ xti=4.5636                eg=1.1188                 tlev=1
+ tlevc=1                   tbf1=0.00563              tbf2=-1.2e-006
+ tbr1=0.00097425           tbr2=-5e-006              tikf1=-0.0064
+ tikr1=-0.005              tnc1=0.00077283           tne1=9.5e-005
+ tne2=-6e-007              tnf1=-0.00015             tnf2=1.09e-007
+ tnr1=-0.00018486          tvaf1=-0.0001736          tvar1=0.00027654
+ cje=3.241e-14*cjea5_rpo   vje=0.726                 mje=0.322
+ cjc=6.883e-14*cjca5_rpo   vjc=0.697                 mjc=0.348
+ fc=0                      ctc=0.0015                cte=0.00099
+ tvjc=0.00211              tvje=0.00171              rbmod=spice
+ minr=1e-3
 
// 
// 
model npn2_5_rpo bjt type=npn 
+ is=1.15e-018*isa5_rpo     bf=15.84*bfa5_rpo         nf=1*nfa5_rpo
+ vaf=73.379                ikf=0.0019608             ise=2.2577e-017*isa5_rpo
+ ne=1.377                  br=0.12255                nr=1
+ var=24.527                ikr=0.53694               isc=6.3126e-018*isa5_rpo
+ nc=1.095                  rb=15*rba5_rpo            irb=0.001
+ rbm=0.1*rbma5_rpo         re=39.305*rea5_rpo        rc=13*rca5_rpo
+ nkf=0.31024               tnom=25                   xtb=0
+ xti=1.4                   eg=1.241                  tlev=1
+ tlevc=1                   tbf1=0.00595              tbf2=3.7461e-006
+ tbr1=0.00074777           tbr2=-2.8e-006            tikf1=-0.0060271
+ tikf2=1e-005              tikr1=0.01                tnc1=8.437e-005
+ tne1=0.00028              tne2=-5e-007              tnf1=5.8194e-005
+ tnf2=-1e-007              tnr1=-9.2348e-005         trb1=0.00073621
+ cje=6.064e-15*cjea5_rpo   vje=0.726                 mje=0.322
+ cjc=3.952e-14*cjca5_rpo   vjc=0.697                 mjc=0.348
+ fc=0                      ctc=0.0015                cte=0.00099
+ tvjc=0.00211              tvje=0.00171              rbmod=spice
+ minr=1e-3
 
// 
// 
// 
subckt pnp10_5_rpo_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip5_rpo multi=1 is5mis10=1 + 8.8e-3 * (1 / 
+ sqrt(multi * 10e-6 * 10e-6 * 1e12)) * par5_rpo_bjtp1 * mismatchflag bf5mis10=1 
+ + 2e-2 * (1 / sqrt(multi * 10e-6 * 10e-6 * 1e12)) * par5_rpo_bjtp2 * mismatchflag 
qin ( c b e ) pnp10_5_rpo m=multi
// 
model pnp10_5_rpo bjt type=pnp 
+ is=1.27e-017*isa5_rpo*is5mis10                      bf=2.96*bfa5_rpo*bf5mis10
+ nf=1.002*nfa5_rpo         vaf=610.81                ikf=0.0029097
+ ise=4.2367e-016*isa5_rpo/bf5mis10                   ne=1.495
+ br=0.0379                 nr=0.99928                var=24.184
+ ikr=0.01                  isc=3.4782e-015*isa5_rpo  nc=1.066
+ rb=10.31*rba5_rpo         irb=0.001                 rbm=0.1*rbma5_rpo
+ re=4.92*rea5_rpo          rc=14.687*rca5_rpo        nkf=0.57044
+ tnom=25                   xtb=0                     xti=3.4659
+ eg=1.1578                 tlev=1                    tlevc=1
+ tbf1=0.0050748            tbf2=2.8e-006             tikf1=-0.003381
+ tikr1=0.00514             tnc1=2.694e-005           tnc2=8e-007
+ tne2=-4e-007              tnf1=-4.08e-005           tnf2=1e-007
+ tnr1=3.7107e-005          tvar1=0.00138             cje=1.300e-13*cjea5_rpo
+ vje=0.822                 mje=0.367                 cjc=6.150e-14*cjca5_rpo
+ vjc=0.567                 mjc=0.354                 fc=0
+ ctc=0.0026                cte=0.000954              tvjc=0.00255
+ tvje=0.00165              rbmod=spice               minr=1e-3
// 
ends pnp10_5_rpo_mis
// 
// 
subckt pnp5_5_rpo_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip5_rpo multi=1 is5mis5=1 + 8.8e-3 * (1 / 
+ sqrt(multi * 5e-6 * 5e-6 * 1e12)) * par5_rpo_bjtp1 * mismatchflag bf5mis5=1 + 
+ 2e-2 * (1 / sqrt(multi * 5e-6 * 5e-6 * 1e12)) * par5_rpo_bjtp2 * mismatchflag 
qin ( c b e ) pnp5_5_rpo m=multi
// 
model pnp5_5_rpo bjt type=pnp 
+ is=3.43e-018*isa5_rpo*is5mis5                       bf=3.104*bfa5_rpo*bf5mis5
+ nf=1.002*nfa5_rpo         vaf=581.99                ikf=0.001697
+ ise=1.6345e-016*isa5_rpo/bf5mis5                    ne=1.495
+ br=0.5                    nr=1.0144                 var=22.39
+ ikr=0.01                  isc=3.1504e-015*isa5_rpo  nc=1.082
+ rb=20*rba5_rpo            irb=0.001                 rbm=0.1*rbma5_rpo
+ re=7.325*rea5_rpo         rc=5*rca5_rpo             nkf=0.53564
+ tnom=25                   xtb=0                     xti=1.93
+ eg=1.206                  tlev=1                    tlevc=1
+ tbf1=0.0054742            tbf2=5.28e-006            tbr1=0.003545
+ tikf1=-0.0024519          tikr1=0.00534             tnc1=-0.00019674
+ tnc2=1.6e-007             tne1=-0.00029             tne2=-1.4e-006
+ tnf1=-7.5e-007            tnf2=-1.5e-007            tnr1=-7.5409e-005
+ cje=3.448e-14*cjea5_rpo   vje=0.822                 mje=0.367
+ cjc=3.557e-14*cjca5_rpo   vjc=0.567                 mjc=0.354
+ fc=0                      ctc=0.0026                cte=0.000954
+ tvjc=0.00255              tvje=0.00165              rbmod=spice
+ minr=1e-3
// 
ends pnp5_5_rpo_mis
// 
// 
subckt pnp2_5_rpo_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip5_rpo multi=1 is5mis2=1 + 8.8e-3 * (1 / 
+ sqrt(multi * 2e-6 * 2e-6 * 1e12)) * par5_rpo_bjtp1 * mismatchflag bf5mis2=1 + 
+ 2e-2 * (1 / sqrt(multi * 2e-6 * 2e-6 * 1e12)) * par5_rpo_bjtp2 * mismatchflag 
qin ( c b e ) pnp2_5_rpo m=multi
// 
model pnp2_5_rpo bjt type=pnp 
+ is=7.18e-019*isa5_rpo*is5mis2                       bf=3.8*bfa5_rpo*bf5mis2
+ nf=1.002*nfa5_rpo         vaf=300                   ikf=0.00050879
+ ise=1.5204e-016*isa5_rpo/bf5mis2                    ne=1.524
+ br=0.58612                nr=1.0084                 var=19.037
+ ikr=0.03634               isc=1.6129e-015*isa5_rpo  nc=1.0595
+ rb=36*rba5_rpo            irb=0.001                 rbm=0.1*rbma5_rpo
+ re=22.976*rea5_rpo        rc=20.8*rca5_rpo          nkf=0.48338
+ tnom=25                   xtb=0                     xti=3.0048
+ eg=1.1546                 tlev=1                    tlevc=1
+ tbf1=0.00633              tbf2=8.611e-006           tikf1=-0.0040544
+ tikr1=0.00402             tnc1=-0.000395            tnc2=3.3e-007
+ tne1=-5e-005              tne2=1.2e-006             tnf1=-0.00013
+ tnf2=-2e-007              tnr1=-0.000336            tre1=-0.002
+ tvaf1=-0.005699           cje=6.472e-15*cjea5_rpo   vje=0.822
+ mje=0.367                 cjc=2.294e-14*cjca5_rpo   vjc=0.567
+ mjc=0.354                 fc=0                      ctc=0.0026
+ cte=0.000954              tvjc=0.00255              tvje=0.00165
+ rbmod=spice               minr=1e-3
// 
ends pnp2_5_rpo_mis
// 
// 
subckt npn10_5_rpo_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip5_rpo multi=1 is5mis10=1 + 8e-3 * (1 / sqrt(multi 
+ * 10e-6 * 10e-6 * 1e12)) * par5_rpo_bjtn1 * mismatchflag bf5mis10=1 + 3.6e-2 * 
+ (1 / sqrt(multi * 10e-6 * 10e-6 * 1e12)) * par5_rpo_bjtn2 * mismatchflag 
qin ( c b e ) npn10_5_rpo m=multi
// 
model npn10_5_rpo bjt type=npn 
+ is=2.35e-017*isa5_rpo*is5mis10                      bf=10*bfa5_rpo*bf5mis10
+ nf=1.001*nfa5_rpo         vaf=90.842                ikf=0.093495
+ ise=2.2081e-016*isa5_rpo/bf5mis10                   ne=1.4567
+ br=0.752                  nr=1                      var=26.893
+ ikr=0.025284              isc=1.0646e-015*isa5_rpo  nc=1.9
+ rb=4.52*rba5_rpo          irb=0.001                 rbm=0.1*rbma5_rpo
+ re=8.5*rea5_rpo           rc=9.1*rca5_rpo           nkf=0.8989
+ tnom=25                   xtb=0                     xti=3.2298
+ eg=1.1722                 tlev=1                    tlevc=1
+ tbf1=0.00533              tbf2=-2.1e-006            tbr1=0.00097267
+ tbr2=-4.14e-006           tikf1=-0.0050686          tikr1=0.0048388
+ tne1=0.00038871           tnf1=-3.88e-005           tnf2=3e-007
+ tvaf1=-0.00303            tvar1=3.9259e-005         cje=1.223e-13*cjea5_rpo
+ vje=0.726                 mje=0.322                 cjc=1.352e-13*cjca5_rpo
+ vjc=0.697                 mjc=0.348                 fc=0
+ ctc=0.0015                cte=0.00099               tvjc=0.00211
+ tvje=0.00171              rbmod=spice               minr=1e-3
// 
ends npn10_5_rpo_mis
// 
// 
subckt npn5_5_rpo_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip5_rpo multi=1 is5mis5=1 + 8e-3 * (1 / sqrt(multi 
+ * 5e-6 * 5e-6 * 1e12)) * par5_rpo_bjtn1 * mismatchflag bf5mis5=1 + 3.6e-2 * (1 
+ / sqrt(multi * 5e-6 * 5e-6 * 1e12)) * par5_rpo_bjtn2 * mismatchflag 
qin ( c b e ) npn5_5_rpo m=multi
// 
model npn5_5_rpo bjt type=npn 
+ is=6.4e-018*isa5_rpo*is5mis5                        bf=11.28*bfa5_rpo*bf5mis5
+ nf=1.001*nfa5_rpo         vaf=80.393                ikf=0.1
+ ise=7.4429e-017*isa5_rpo/bf5mis5                    ne=1.415
+ br=0.36988                nr=1.0021                 var=25.604
+ ikr=1                     isc=3.6669e-016*isa5_rpo  nc=1.84
+ rb=5*rba5_rpo             irb=0.001                 rbm=0.1*rbma5_rpo
+ re=17*rea5_rpo            rc=10.863*rca5_rpo        nkf=0.95
+ tnom=25                   xtb=0                     xti=4.5636
+ eg=1.1188                 tlev=1                    tlevc=1
+ tbf1=0.00563              tbf2=-1.2e-006            tbr1=0.00097425
+ tbr2=-5e-006              tikf1=-0.0064             tikr1=-0.005
+ tnc1=0.00077283           tne1=9.5e-005             tne2=-6e-007
+ tnf1=-0.00015             tnf2=1.09e-007            tnr1=-0.00018486
+ tvaf1=-0.0001736          tvar1=0.00027654          cje=3.241e-14*cjea5_rpo
+ vje=0.726                 mje=0.322                 cjc=6.883e-14*cjca5_rpo
+ vjc=0.697                 mjc=0.348                 fc=0
+ ctc=0.0015                cte=0.00099               tvjc=0.00211
+ tvje=0.00171              rbmod=spice               minr=1e-3
// 
ends npn5_5_rpo_mis
// 
// 
subckt npn2_5_rpo_mis ( c b e ) 
parameters mismatchflag=mismatchflag_bip5_rpo multi=1 is5mis2=1 + 8e-3 * (1 / sqrt(multi 
+ * 2e-6 * 2e-6 * 1e12)) * par5_rpo_bjtn1 * mismatchflag bf5mis2=1 + 3.6e-2 * (1 
+ / sqrt(multi * 2e-6 * 2e-6 * 1e12)) * par5_rpo_bjtn2 * mismatchflag 
qin ( c b e ) npn2_5_rpo m=multi
// 
model npn2_5_rpo bjt type=npn 
+ is=1.15e-018*isa5_rpo*is5mis2                       bf=15.84*bfa5_rpo*bf5mis2
+ nf=1*nfa5_rpo             vaf=73.379                ikf=0.0019608
+ ise=2.2577e-017*isa5_rpo/bf5mis2                    ne=1.377
+ br=0.12255                nr=1                      var=24.527
+ ikr=0.53694               isc=6.3126e-018*isa5_rpo  nc=1.095
+ rb=15*rba5_rpo            irb=0.001                 rbm=0.1*rbma5_rpo
+ re=39.305*rea5_rpo        rc=13*rca5_rpo            nkf=0.31024
+ tnom=25                   xtb=0                     xti=1.4
+ eg=1.241                  tlev=1                    tlevc=1
+ tbf1=0.00595              tbf2=3.7461e-006          tbr1=0.00074777
+ tbr2=-2.8e-006            tikf1=-0.0060271          tikf2=1e-005
+ tikr1=0.01                tnc1=8.437e-005           tne1=0.00028
+ tne2=-5e-007              tnf1=5.8194e-005          tnf2=-1e-007
+ tnr1=-9.2348e-005         trb1=0.00073621           cje=6.064e-15*cjea5_rpo
+ vje=0.726                 mje=0.322                 cjc=3.952e-14*cjca5_rpo
+ vjc=0.697                 mjc=0.348                 fc=0
+ ctc=0.0015                cte=0.00099               tvjc=0.00211
+ tvje=0.00171              rbmod=spice               minr=1e-3
// 
ends npn2_5_rpo_mis
// 
endsection bip5_rpo
// 
 
// **************************************************************
//                                                              *
//                  1.8V Std-Vt Junction DIODE MODELS           *
//                                                              *
// **************************************************************
// ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_dio
parameters is_d=1.0
parameters jsw_d=1.0
parameters n_d=1.000
parameters rs_d=1.0
parameters cj_d=1.00
parameters cjsw_d=1.00
include "cmn018_gp2a_5v_v1d4.scs" section=dio
endsection tt_dio
// *****************************    LIBRARY OF SLOW CASE    ******************************

section ss_dio
parameters is_d=0.7
parameters jsw_d=0.5
parameters n_d=0.9975
parameters rs_d=1.2
parameters cj_d=1.07
parameters cjsw_d=1.07
include "cmn018_gp2a_5v_v1d4.scs" section=dio
endsection ss_dio
// *****************************    LIBRARY OF FAST CASE    ******************************

section ff_dio
parameters is_d=1.3
parameters jsw_d=2.0
parameters n_d=1.0025
parameters rs_d=0.8
parameters cj_d=0.93
parameters cjsw_d=0.93
include "cmn018_gp2a_5v_v1d4.scs" section=dio
endsection ff_dio
// 

section dio
// 
// **************************************************************
//                       MODEL OF N+/PW DIODE                   *
// **************************************************************
model ndio diode 
+ is=4.98e-7*is_d           isw=4.12e-13*jsw_d        rs=1.0e-10*rs_d
+ n=1.06*n_d                cj=9.81e-04*cj_d          cjsw=1.185e-10*cjsw_d
+ bv=11.25                  area=3.78e-8              pj=9.59e-4
+ mj=0.359                  mjsw=0.202                vj=0.6882682
+ vjsw=0.32                 trs=1.3e-3                tbv1=-1*-8.8e-4
+ cta=9.05e-4               ctp=8.09e-04              pta=1.49e-3
+ ptp=8.94e-04              ibv=0.03                  tnom=25
+ fc=0                      tlev=1                    tlevc=1
+ xti=3                     eg=1.17                   level=1
+ ns=1.06*n_d               nz=1.06*n_d               imax=1e40
+ minr=1e-10                allow_scaling=yes
 
// **************************************************************
//                       MODEL OF P+/NW DIODE                   *
// **************************************************************
model pdio diode 
+ level=1                   is=1.760e-7*is_d          rs=1.0e-10*rs_d
+ n=1.02*n_d                bv=10.2                   ibv=1e-3
+ isw=2.71e-13*jsw_d        area=3.78e-8              pj=9.59e-4
+ cj=1.12e-3*cj_d           vj=0.860                  mj=0.440
+ cjsw=1.345e-10*cjsw_d     vjsw=0.6                  mjsw=0.338
+ tlev=1                    eg=1.17                   xti=3
+ tbv1=-1*-8.8e-4           trs=1.2e-4                tlevc=1
+ cta=9.18e-04              ctp=8.86e-04              pta=1.61e-03
+ ptp=1.25e-03              tnom=25                   fc=0
+ ns=1.02*n_d               nz=1.02*n_d               imax=1e40
+ minr=1e-10                allow_scaling=yes
// **************************************************************
//                       MODEL OF NW/Psub DIODE                 *
// **************************************************************
model nwdio diode 
+ level=1                   is=6.50e-7*is_d           rs=1.0e-10*rs_d
+ n=1.03*n_d                bv=14.75                  ibv=1e-3
+ isw=9.75e-13*jsw_d        area=7.5e-8               pj=1.1e-3
+ cj=1.337566e-4*cj_d       vj=0.5846489              mj=0.3883243
+ cjsw=5.333577e-10*cjsw_d  vjsw=0.5846489            mjsw=0.2345684
+ tlev=1                    eg=1.17                   xti=3
+ tbv1=-1*-9.6e-4           trs=1.125e-3              tlevc=1
+ cta=2.8425e-3             ctp=1.5284e-3             pta=2.819e-3
+ ptp=2.819e-3              tnom=25                   fc=0
+ ns=1.03*n_d               nz=1.03*n_d               imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
endsection dio
// 
// **************************************************************
//                                                              *
//             5V Junction DIODE MODELS                         *
//                                                              *
// **************************************************************
// 
// ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_dio_5
parameters is_d_5=1
parameters x_jsw_d_5=0
parameters n_d_5=1
parameters rs_d_5=1
parameters cj_d_5=1
parameters cjsw_d_5=1
include "cmn018_gp2a_5v_v1d4.scs" section=dio_5
endsection tt_dio_5
// *****************************    LIBRARY OF SLOW CASE    ******************************

section ss_dio_5
parameters is_d_5=0.7
parameters x_jsw_d_5=-1
parameters n_d_5=0.9975
parameters rs_d_5=1.2
parameters cj_d_5=1.07
parameters cjsw_d_5=1.07
include "cmn018_gp2a_5v_v1d4.scs" section=dio_5
endsection ss_dio_5
// *****************************    LIBRARY OF FAST CASE    ******************************

section ff_dio_5
parameters is_d_5=1.3
parameters x_jsw_d_5=1
parameters n_d_5=1.0025
parameters rs_d_5=0.8
parameters cj_d_5=0.93
parameters cjsw_d_5=0.93
include "cmn018_gp2a_5v_v1d4.scs" section=dio_5
endsection ff_dio_5
// 

section dio_5
// 
// **************************************************************
//                    MODEL OF 5V N+/PW DIODE                   *
// **************************************************************
model ndio_5 diode 
+ level=1                   n=1.02*n_d_5              is=2.72e-07*is_d_5
+ isw=1.32e-13*pow(2,x_jsw_d_5)                       bv=9.2
+ tbv1=-1*-0.000596         rs=1.0e-10*rs_d_5         ibv=0.03
+ trs=2.5e-3                cj=0.00115*cj_d_5         vj=0.726
+ mj=0.322                  cta=0.00099               pta=0.00171
+ cjsw=1.83e-10*cjsw_d_5    vjsw=0.406                mjsw=0.118
+ ctp=0.00125               ptp=0.0023                jtun=4.82e-05
+ jtunsw=4.64e-10           ntun=180                  egtun=0.5*1.17
+ xtitun=3                  xti=3                     eg=1.17
+ fc=0                      tnom=25                   tlev=1
+ tlevc=1                   pj=9.1e-4                 area=2.2e-8
+ ns=1.02*n_d_5             nz=1.02*n_d_5             imax=1e40
+ minr=1e-10                allow_scaling=yes
//  
// ************************************************************** 
//                    MODEL OF 5V P+/NW DIODE                   * 
// ************************************************************** 
model pdio_5 diode 
+ level=1                   n=1.02*n_d_5              is=1.94e-07*is_d_5
+ isw=7.03e-14*pow(2,x_jsw_d_5)                       bv=8.4
+ tbv1=-1*-0.000644         rs=1.0e-10*rs_d_5         ibv=0.03
+ trs=2.5e-3                cj=0.00122*cj_d_5         vj=0.822
+ mj=0.367                  cta=0.000954              pta=0.00165
+ cjsw=1.99e-10*cjsw_d_5    vjsw=0.767                mjsw=0.275
+ ctp=0.0007                ptp=0.0016                jtun=1e-09
+ jtunsw=1.64e-10           ntun=49.6                 egtun=0.49*1.17
+ xtitun=3                  xti=3                     eg=1.17
+ fc=0                      tnom=25                   tlev=1
+ tlevc=1                   pj=9.1e-4                 area=2.2e-8
+ ns=1.02*n_d_5             nz=1.02*n_d_5             imax=1e40
+ minr=1e-10                allow_scaling=yes
//  
// ************************************************************** 
//                    MODEL OF 5V NW/Psub DIODE                 * 
// ************************************************************** 
model nwdio_5 diode 
+ level=1                   n=1.02*n_d_5              is=1.45e-06*is_d_5
+ isw=6.13e-13*pow(2,x_jsw_d_5)                       bv=15
+ tbv1=-1*-0.001            rs=1.0e-10*rs_d_5         ibv=0.03
+ trs=2.5e-3                cj=0.000122*cj_d_5        vj=0.567
+ mj=0.354                  cta=0.0026                pta=0.00255
+ cjsw=4.73e-10*cjsw_d_5    vjsw=0.468                mjsw=0.217
+ ctp=0.0013                ptp=0.0019                jtun=5e-05
+ jtunsw=9e-11              ntun=220                  egtun=0.56*1.17
+ xtitun=3                  xti=3                     eg=1.17
+ fc=0                      tnom=25                   tlev=1
+ tlevc=1                   pj=1.11e-3                area=2.75e-8
+ ns=1.02*n_d_5             nz=1.02*n_d_5             imax=1e40
+ minr=1e-10                allow_scaling=yes
//  
endsection dio_5
 
// 
// **************************************************************
//                                                              *
//              1.8V Med-Vt Junction DIODE MODELS               *
//                                                              *
// **************************************************************
// ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_dio_m
parameters is_d_m=1.0
parameters jsw_d_m=1.0
parameters n_d_m=1.000
parameters rs_d_m=1.0
parameters cj_d_m=1.00
parameters cjsw_d_m=1.00
include "cmn018_gp2a_5v_v1d4.scs" section=dio_m
endsection tt_dio_m
// *****************************    LIBRARY OF SLOW CASE    ******************************

section ss_dio_m
parameters is_d_m=0.7
parameters jsw_d_m=0.5
parameters n_d_m=0.9975
parameters rs_d_m=1.2
parameters cj_d_m=1.07
parameters cjsw_d_m=1.07
include "cmn018_gp2a_5v_v1d4.scs" section=dio_m
endsection ss_dio_m
// *****************************    LIBRARY OF FAST CASE    ******************************

section ff_dio_m
parameters is_d_m=1.3
parameters jsw_d_m=2.0
parameters n_d_m=1.0025
parameters rs_d_m=0.8
parameters cj_d_m=0.93
parameters cjsw_d_m=0.93
include "cmn018_gp2a_5v_v1d4.scs" section=dio_m
endsection ff_dio_m
// 

section dio_m
// 
// **************************************************************
//             MODEL OF 5V Med-Vt N+/PW DIODE                   *
// **************************************************************
model ndio_m diode 
+ is=2.34e-7*is_d_m         isw=7.68e-13*jsw_d_m      rs=1.0e-10*rs_d_m
+ n=1.005*n_d_m             cj=9.13e-04*cj_d_m        cjsw=1.04e-10*cjsw_d_m
+ bv=11.3                   area=3.78e-8              pj=9.59e-4
+ mj=0.333                  mjsw=0.146                vj=0.6882682
+ vjsw=0.290                trs=1.3e-3                tbv1=-1*-9.3e-4
+ cta=9.13e-4               ctp=7.65e-04              pta=1.49e-03
+ ptp=1.00e-03              ibv=0.03                  tnom=25
+ fc=0                      tlev=1                    tlevc=1
+ xti=3                     eg=1.17                   level=1
+ ns=1.005*n_d_m            nz=1.005*n_d_m            imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
// ************************************************************** 
//             MODEL OF 5V Med-Vt P+/NW DIODE                   * 
// ************************************************************** 
model pdio_m diode 
+ level=1                   is=1.48e-7*is_d_m         rs=1.0e-10*rs_d_m
+ n=1.005*n_d_m             bv=11.1                   ibv=1e-3
+ isw=4.06e-13*jsw_d_m      area=3.78e-8              pj=9.59e-4
+ cj=1.05e-3*cj_d_m         vj=0.886                  mj=0.440
+ cjsw=1.26e-10*cjsw_d_m    vjsw=0.600                mjsw=0.338
+ tlev=1                    eg=1.17                   xti=3
+ tbv1=-1*-8.8e-4           trs=1.2e-4                tlevc=1
+ cta=9.18e-04              ctp=8.86e-04              pta=1.61e-03
+ ptp=1.25e-03              tnom=25                   fc=0
+ ns=1.005*n_d_m            nz=1.005*n_d_m            imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
endsection dio_m
// 
// **************************************************************
//                                                              *
//                  5V Med-Vt Junction DIODE MODELS             *
//                                                              *
// **************************************************************
// ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_dio_5m
parameters is_d_5m=1.0
parameters jsw_d_5m=1.0
parameters n_d_5m=1.000
parameters rs_d_5m=1.0
parameters cj_d_5m=1.00
parameters cjsw_d_5m=1.00
include "cmn018_gp2a_5v_v1d4.scs" section=dio_5m
endsection tt_dio_5m
// *****************************    LIBRARY OF SLOW CASE    ******************************

section ss_dio_5m
parameters is_d_5m=0.7
parameters jsw_d_5m=0.5
parameters n_d_5m=0.9975
parameters rs_d_5m=1.2
parameters cj_d_5m=1.07
parameters cjsw_d_5m=1.07
include "cmn018_gp2a_5v_v1d4.scs" section=dio_5m
endsection ss_dio_5m
// *****************************    LIBRARY OF FAST CASE    ******************************

section ff_dio_5m
parameters is_d_5m=1.3
parameters jsw_d_5m=2.0
parameters n_d_5m=1.0025
parameters rs_d_5m=0.8
parameters cj_d_5m=0.93
parameters cjsw_d_5m=0.93
include "cmn018_gp2a_5v_v1d4.scs" section=dio_5m
endsection ff_dio_5m
// 

section dio_5m
//  
// ************************************************************** 
//                       MODEL OF N+/PW DIODE                   * 
// ************************************************************** 
model ndio_5m diode 
+ level=1                   n=1.02*n_d_5m             is=4.865e-7*is_d_5m
+ isw=2.498e-12*jsw_d_5m    rs=1.000e-10*rs_d_5m      bv=9.3
+ ibv=0.03                  fc=0                      cj=1.179e-3*cj_d_5m
+ vj=0.702                  mj=0.308                  cjsw=2.224e-10*cjsw_d_5m
+ vjsw=0.394                mjsw=0.096                cta=7.372e-4
+ ctp=5.458e-4              pta=1.400e-3              ptp=1.6e-3
+ tlev=1                    eg=1.172                  xti=3
+ tlevc=1                   trs=2.500e-03             tbv1=-1*-6.452e-4
+ tnom=25                   area=2.2e-8               pj=9.1e-4
+ ns=1.02*n_d_5m            nz=1.02*n_d_5m            imax=1e40
+ minr=1e-10                allow_scaling=yes
// ************************************************************** 
//                       MODEL OF P+/NW DIODE                   * 
// ************************************************************** 
 
model pdio_5m diode 
+ level=1                   n=1.02*n_d_5m             is=3.815e-7*is_d_5m
+ isw=3.008e-12*jsw_d_5m    rs=1.000e-10*rs_d_5m      bv=9.8
+ ibv=0.03                  fc=0                      cj=1.040e-3*cj_d_5m
+ vj=0.815                  mj=0.357                  cjsw=1.664e-10*cjsw_d_5m
+ vjsw=0.669                mjsw=0.236                cta=7.07e-04
+ ctp=7.104e-4              pta=1.31e-03              ptp=1.633e-3
+ tlev=1                    eg=1.172                  xti=3
+ tlevc=1                   trs=2.500e-03             tbv1=-1*-7.143e-4
+ tnom=25                   area=2.2e-8               pj=9.1e-4
+ ns=1.02*n_d_5m            nz=1.02*n_d_5m            imax=1e40
+ minr=1e-10                allow_scaling=yes
 
endsection dio_5m
// **************************************************************
//                                                              *
//              DNW Junction DIODE MODELS                       *
//                                                              *
// **************************************************************
// ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_dio_dnw
parameters is_d_dnw=1.0
parameters jsw_d_dnw=1.0
parameters n_d_dnw=1.000
parameters rs_d_dnw=1.0
parameters cj_d_dnw=1.00
parameters cjsw_d_dnw=1.00
include "cmn018_gp2a_5v_v1d4.scs" section=dio_dnw
endsection tt_dio_dnw
// *****************************    LIBRARY OF SLOW CASE    ******************************

section ss_dio_dnw
parameters is_d_dnw=0.7
parameters jsw_d_dnw=0.5
parameters n_d_dnw=0.9975
parameters rs_d_dnw=1.2
parameters cj_d_dnw=1.07
parameters cjsw_d_dnw=1.07
include "cmn018_gp2a_5v_v1d4.scs" section=dio_dnw
endsection ss_dio_dnw
// *****************************    LIBRARY OF FAST CASE    ******************************

section ff_dio_dnw
parameters is_d_dnw=1.3
parameters jsw_d_dnw=2.0
parameters n_d_dnw=1.0025
parameters rs_d_dnw=0.8
parameters cj_d_dnw=0.93
parameters cjsw_d_dnw=0.93
include "cmn018_gp2a_5v_v1d4.scs" section=dio_dnw
endsection ff_dio_dnw
 

section dio_dnw
// 
// **************************************************************
//                    MODEL OF DNW/PSUB DIODE                   *
// **************************************************************
model dnwpsub diode 
+ level=1                   n=1.02*n_d_dnw            is=1.9e-06*is_d_dnw
+ isw=3.500e-12*jsw_d_dnw   rs=1.0e-10*rs_d_dnw       bv=14.3
+ ibv=0.001                 fc=0                      cj=1.393e-04*cj_d_dnw
+ vj=0.7                    mj=0.36                   cjsw=9.15e-10*cjsw_d_dnw
+ vjsw=0.45                 mjsw=0.3                  cta=1.300e-03
+ ctp=1.400e-03             pta=1.800e-03             ptp=1.500e-03
+ tlev=1                    eg=1.170                  xti=3
+ tlevc=1                   trs=3.350e-03             tbv1=-1*-0.00094
+ tnom=25                   area=2.75e-8              pj=1.11e-3
+ ns=1.02*n_d_dnw           nz=1.02*n_d_dnw           imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
// **************************************************************
//                   1.8V MODEL OF PW/DNW DIODE                 *
// **************************************************************
// 
model pwdnw diode 
+ level=1                   n=1.02*n_d_dnw            is=5.500e-07*is_d_dnw
+ isw=2.0e-12*jsw_d_dnw     rs=1.0e-10*rs_d_dnw       bv=15.1
+ ibv=0.001                 fc=0                      cj=4.660e-04*cj_d_dnw
+ vj=0.75                   mj=0.37                   cjsw=3.07e-10*cjsw_d_dnw
+ vjsw=0.59                 mjsw=0.255                cta=1.100e-03
+ ctp=8.000e-04             pta=1.850e-03             ptp=1.500e-03
+ tlev=1                    eg=1.170                  xti=3
+ tlevc=1                   trs=3.440e-03             tbv1=-1*-0.0011
+ tnom=25                   area=2.75e-8              pj=1.11e-3
+ ns=1.02*n_d_dnw           nz=1.02*n_d_dnw           imax=1e40
+ minr=1e-10                allow_scaling=yes
// 
endsection dio_dnw
// 
// **************************************************************
//                                                              *
//           5V PW/DNW Junction DIODE MODELS                    *
//                                                              *
// **************************************************************
// ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_dio_dnw_5
parameters is_d_dnw_5=1
parameters x_jsw_d_dnw_5=0
parameters n_d_dnw_5=1
parameters rs_d_dnw_5=1
parameters cj_d_dnw_5=1
parameters cjsw_d_dnw_5=1
include "cmn018_gp2a_5v_v1d4.scs" section=dio_dnw_5
endsection tt_dio_dnw_5
// *****************************    LIBRARY OF SLOW CASE    ******************************

section ss_dio_dnw_5
parameters is_d_dnw_5=0.7
parameters x_jsw_d_dnw_5=-1
parameters n_d_dnw_5=0.9975
parameters rs_d_dnw_5=1.2
parameters cj_d_dnw_5=1.07
parameters cjsw_d_dnw_5=1.07
include "cmn018_gp2a_5v_v1d4.scs" section=dio_dnw_5
endsection ss_dio_dnw_5
// *****************************    LIBRARY OF FAST CASE    ****************************** 
//     

section ff_dio_dnw_5
parameters is_d_dnw_5=1.3
parameters x_jsw_d_dnw_5=1
parameters n_d_dnw_5=1.0025
parameters rs_d_dnw_5=0.8
parameters cj_d_dnw_5=0.93
parameters cjsw_d_dnw_5=0.93
include "cmn018_gp2a_5v_v1d4.scs" section=dio_dnw_5
endsection ff_dio_dnw_5
 

section dio_dnw_5
// **************************************************************
//                   MODEL OF 5V PW/DNW DIODE                   *
// **************************************************************
model pwdnw_5 diode 
+ level=1                   n=1.02*n_d_dnw_5          is=1.66e-07*is_d_dnw_5
+ isw=1.38e-13*pow(2,x_jsw_d_dnw_5)                   bv=14.2
+ tbv1=-1*-0.00104          rs=1.0e-10*rs_d_dnw_5     ibv=0.03
+ trs=2.5e-3                cj=0.000439*cj_d_dnw_5    vj=0.697
+ mj=0.348                  cta=0.0015                pta=0.00211
+ cjsw=3.57e-10*cjsw_d_dnw_5                          vjsw=0.644
+ mjsw=0.266                ctp=0.00105               ptp=0.00187
+ jtun=6.26e-06             jtunsw=4.33e-11           ntun=145
+ egtun=0.51*1.17           xtitun=3                  xti=3
+ eg=1.17                   fc=0                      tnom=25
+ tlev=1                    tlevc=1                   pj=1.11e-3
+ area=2.75e-8              ns=1.02*n_d_dnw_5         nz=1.02*n_d_dnw_5
+ imax=1e40                 minr=1e-10                allow_scaling=yes
// 
endsection dio_dnw_5
// 
// **************************************************************
//                                                              *
//                2T Resistor model                              *
//                                                              *
// **************************************************************
// **************************     COMMON STATISTICAL LIBRARY      ***************************

section stat_res
parameters random1_res=0
parameters random2_res=0
parameters random3_res=0
parameters random4_res=0
parameters random5_res=0
parameters par1_res=random1_res
parameters par2_res=random2_res
parameters par3_res=random3_res
parameters par4_res=random4_res
parameters par5_res=random5_res

statistics {
    process {
        vary random1_res dist=gauss std=1/1
        vary random2_res dist=gauss std=1/1
        vary random3_res dist=gauss std=1/1
        vary random4_res dist=gauss std=1/1
        vary random5_res dist=gauss std=1/1
        }
    }
endsection stat_res
 
 
 
 
 

section stat_disres
parameters random1_disres=0
parameters random2_disres=0
parameters random3_disres=0
parameters random4_disres=0
parameters par1_disres=random1_disres
parameters par2_disres=random2_disres
parameters par3_disres=random3_disres
parameters par4_disres=random4_disres

statistics {
    process {
        vary random1_disres dist=gauss std=1/1
        vary random2_disres dist=gauss std=1/1
        vary random3_disres dist=gauss std=1/1
        vary random4_disres dist=gauss std=1/1
        }
    }
endsection stat_disres
 
 
 
// 

section mc_res
include "cmn018_gp2a_5v_v1d4.scs" section=setup_res
parameters par_res=0
parameters a1_res_sal=par1_res * 3.1623 / 3.0
parameters a1_res_rpo=par2_res * 5.8363 / 3.1
parameters a2_res_rpo=par3_res * 0.96843 / 3.1
parameters a1_res_nw=par4_res * 2.8284 / 3
parameters r_rnod=7.28 + (0.84396) * a1_res_sal
parameters r_rnodw=7.28 + (0.84396) * a1_res_sal
parameters r_rpod=7.49 + (0.91592) * a1_res_sal
parameters r_rpodw=7.49 + (0.91592) * a1_res_sal
parameters r_rnpo1=8.23 + (0.65988) * a1_res_sal
parameters r_rnpo1w=8.23 + (0.65988) * a1_res_sal
parameters r_rppo1=8.41 + (0.84145) * a1_res_sal
parameters r_rppo1w=8.41 + (0.84145) * a1_res_sal
parameters r_rnodrpo=82.9 + (0.97008) * a1_res_rpo + (0.32457) * a2_res_rpo
parameters rend_rnodrpo=0.00001586 + (5.4808e-007) * a1_res_rpo + (1.8338e-007) 
+ * a2_res_rpo
parameters dxl_rnodrpo=0e-06 + ( - 3.9726e-009) * a1_res_rpo + (1.2105e-008) * a2_res_rpo
parameters x_dxw_rnodrpo=0e-06 + (0.17108) * a1_res_rpo + (0.057239) * a2_res_rpo
parameters r_rpodrpo=128.2 + (1.5265) * a1_res_rpo + (0.51074) * a2_res_rpo
parameters rend_rpodrpo=0.0000285 + (8.5325e-007) * a1_res_rpo + (2.8548e-007) * 
+ a2_res_rpo
parameters dxl_rpodrpo=0e-06 + ( - 5.0762e-009) * a1_res_rpo + (1.5468e-008) * a2_res_rpo
parameters x_dxw_rpodrpo=0e-06 + (0.17108) * a1_res_rpo + (0.057239) * a2_res_rpo
parameters r_rnpo1rpo=322.5 + (3.8511) * a1_res_rpo + (1.2888) * a2_res_rpo
parameters rend_rnpo1rpo=0.000105 + (3.7812e-006) * a1_res_rpo + (1.265e-006) * 
+ a2_res_rpo
parameters dxl_rnpo1rpo=0e-06 + ( - 2.5602e-009) * a1_res_rpo + (7.8013e-009) * 
+ a2_res_rpo
parameters x_dxw_rnpo1rpo=0e-06 + (0.17108) * a1_res_rpo + (0.057239) * a2_res_rpo
parameters r_rppo1rpo=350.8 + (4.273) * a1_res_rpo + (1.4296) * a2_res_rpo
parameters rend_rppo1rpo=0.000133 + (3.8084e-006) * a1_res_rpo + ( - 5.1708e-007) 
+ * a2_res_rpo
parameters dxl_rppo1rpo=0e-06 + ( - 2.3394e-009) * a1_res_rpo + (7.1287e-009) * 
+ a2_res_rpo
parameters x_dxw_rppo1rpo=0e-06 + (0.17108) * a1_res_rpo + (0.057239) * a2_res_rpo
parameters r_rppolyhri=1026.123930 + (22.81) * a1_res_rpo + (8.8562) * a2_res_rpo
parameters rend_rppolyhri=1.203938e-04 + (8.5209e-006) * a1_res_rpo + (1.5501e-007) 
+ * a2_res_rpo
parameters x_dxw_rppolyhri=0e-6 + (0.17108) * a1_res_rpo + (0.057239) * a2_res_rpo
parameters r_rppolyhri3k=3110 + (66.336) * a1_res_rpo + (40.764) * a2_res_rpo
parameters rend_rppolyhri3k=0.0000695 + (5.0116e-006) * a1_res_rpo + (1.6767e-006) 
+ * a2_res_rpo
parameters x_dxl_rppolyhri3k=0e-06 + (0.17108) * a1_res_rpo + (0.057239) * a2_res_rpo
parameters x_dxw_rppolyhri3k=0e-06 + (0.17108) * a1_res_rpo + (0.057239) * a2_res_rpo
parameters r_nodrpo_pure5v=83.050 + (0.92125) * a1_res_rpo + (0.55617) * a2_res_rpo
parameters rend_nodrpo_pure5v=2.522e-05 + (1.8023e-006) * a1_res_rpo + ( - 6.7698e-007) 
+ * a2_res_rpo
parameters x_dxw_nodrpo_pure5v=0e-06 + (0.17108) * a1_res_rpo + (0.057239) * a2_res_rpo
parameters r_podrpo_pure5v=120.229 + (1.3867) * a1_res_rpo + (0.64339) * a2_res_rpo
parameters rend_podrpo_pure5v=4.1589e-05 + (7.6772e-007) * a1_res_rpo + ( - 5.3539e-008) 
+ * a2_res_rpo
parameters x_dxw_podrpo_pure5v=0e-06 + (0.17108) * a1_res_rpo + (0.057239) * a2_res_rpo
parameters r_npolyrpo_pure5v=355.35 + (8.109) * a1_res_rpo + (3.4558) * a2_res_rpo
parameters rend_npolyrpo_pure5v=9.561e-05 + (2.6224e-006) * a1_res_rpo + (3.0665e-007) 
+ * a2_res_rpo
parameters x_dxw_npolyrpo_pure5v=0e-06 + (0.17108) * a1_res_rpo + (0.057239) * a2_res_rpo
parameters r_ppolyrpo_pure5v=335 + (4.7144) * a1_res_rpo + (3.0775) * a2_res_rpo
parameters rend_ppolyrpo_pure5v=0.00017 + (4.8552e-006) * a1_res_rpo + (3.4008e-006) 
+ * a2_res_rpo
parameters x_dxw_ppolyrpo_pure5v=0e-06 + (0.17108) * a1_res_rpo + (0.057239) * a2_res_rpo
parameters dxl_rppolyhri=0e-6
parameters dxl_nodrpo_pure5v=0.0e-06
parameters dxl_podrpo_pure5v=0.0e-06
parameters dxl_npolyrpo_pure5v=0.0e-06
parameters dxl_ppolyrpo_pure5v=0.0e-06
parameters r_rm1=0.078
parameters r_rm2=0.078
parameters r_rm3=0.078
parameters r_rm4=0.078
parameters r_rm5=0.078
parameters r_rm6=0.036
parameters r_rmt=0.0178
parameters r_rmu_40k=0.0062
parameters r_rmu_33k=0.0054
parameters r_rmap=0.0105
parameters r_rnwsti=963.6 + (47.355) * a1_res_nw
parameters rend_rnwsti=250e-6 + (1.5026e-005) * a1_res_nw
parameters r_rnwsti_pure5v=1070 + (105.93) * a1_res_nw
parameters rend_rnwsti_pure5v=380e-6 + (4.0305e-005) * a1_res_nw
parameters r_rnwod=416 + (16.179) * a1_res_nw
parameters rend_rnwod=205e-6 + (8.879e-006) * a1_res_nw
parameters r_rnwod_pure5v=586 + (22.79) * a1_res_nw
parameters rend_rnwod_pure5v=250e-6 + (1.0828e-005) * a1_res_nw
 
include "cmn018_gp2a_5v_v1d4.scs" section=res
endsection mc_res
 
 
 
 
// *************************** Typical corner of resistor ***********************************

section tt_res
include "cmn018_gp2a_5v_v1d4.scs" section=setup_res
parameters par_res=0
parameters r_rnod=7.28
parameters r_rnodw=7.28
parameters r_rpod=7.49
parameters r_rpodw=7.49
parameters r_rnpo1=8.23
parameters r_rnpo1w=8.23
parameters r_rppo1=8.41
parameters r_rppo1w=8.41
parameters r_rm1=0.078
parameters r_rm2=0.078
parameters r_rm3=0.078
parameters r_rm4=0.078
parameters r_rm5=0.078
parameters r_rm6=0.036
parameters r_rmt=0.0178
parameters r_rmu_40k=0.0062
parameters r_rmu_33k=0.0054
parameters r_rmap=0.0105
parameters r_rnodrpo=82.9
parameters rend_rnodrpo=0.00001586
parameters dxl_rnodrpo=0e-06
parameters x_dxw_rnodrpo=0e-06
parameters r_rpodrpo=128.2
parameters rend_rpodrpo=0.0000285
parameters dxl_rpodrpo=0e-06
parameters x_dxw_rpodrpo=0e-06
parameters r_rnpo1rpo=322.5
parameters rend_rnpo1rpo=0.000105
parameters dxl_rnpo1rpo=0e-06
parameters x_dxw_rnpo1rpo=0e-06
parameters r_rppo1rpo=350.8
parameters rend_rppo1rpo=0.000133
parameters dxl_rppo1rpo=0e-06
parameters x_dxw_rppo1rpo=0e-06
parameters r_rppolyhri=1026.123930
parameters rend_rppolyhri=1.203938e-04
parameters dxl_rppolyhri=0e-6
parameters x_dxw_rppolyhri=0e-6
parameters r_rppolyhri3k=3110
parameters rend_rppolyhri3k=0.0000695
parameters x_dxl_rppolyhri3k=0e-06
parameters x_dxw_rppolyhri3k=0e-06
parameters r_nodrpo_pure5v=83.050
parameters rend_nodrpo_pure5v=2.522e-05
parameters dxl_nodrpo_pure5v=0.0e-06
parameters x_dxw_nodrpo_pure5v=0e-06
parameters r_podrpo_pure5v=120.229
parameters rend_podrpo_pure5v=4.1589e-05
parameters dxl_podrpo_pure5v=0.0e-06
parameters x_dxw_podrpo_pure5v=0e-06
parameters r_npolyrpo_pure5v=355.35
parameters rend_npolyrpo_pure5v=9.561e-05
parameters dxl_npolyrpo_pure5v=0.0e-06
parameters x_dxw_npolyrpo_pure5v=0e-06
parameters r_ppolyrpo_pure5v=335
parameters rend_ppolyrpo_pure5v=0.00017
parameters dxl_ppolyrpo_pure5v=0.0e-06
parameters x_dxw_ppolyrpo_pure5v=0e-06
parameters r_rnwsti=963.6
parameters rend_rnwsti=250e-6
parameters r_rnwsti_pure5v=1070
parameters rend_rnwsti_pure5v=380e-6
parameters r_rnwod=416
parameters rend_rnwod=205e-6
parameters r_rnwod_pure5v=586
parameters rend_rnwod_pure5v=250e-6
 
include "cmn018_gp2a_5v_v1d4.scs" section=res
endsection tt_res
 
 
 
// *************************** Slow corner of resistor ***********************************

section ss_res
include "cmn018_gp2a_5v_v1d4.scs" section=setup_res
parameters par_res=0
parameters r_rnod=7.28 * 1.3666
parameters r_rnodw=7.28 * 1.3666
parameters r_rpod=7.49 * 1.3867
parameters r_rpodw=7.49 * 1.3867
parameters r_rnpo1=8.23 * 1.2534
parameters r_rnpo1w=8.23 * 1.2534
parameters r_rppo1=8.41 * 1.3164
parameters r_rppo1w=8.41 * 1.3164
parameters r_rm1=0.078 + 0.023
parameters r_rm2=0.078 + 0.023
parameters r_rm3=0.078 + 0.023
parameters r_rm4=0.078 + 0.023
parameters r_rm5=0.078 + 0.023
parameters r_rm6=0.036 + 0.009
parameters r_rmt=0.0178 + 0.00623
parameters r_rmu_40k=0.0062 + 0.001
parameters r_rmu_33k=0.0054 + 0.0016
parameters r_rmap=0.0105 + 0.0042
parameters r_rnodrpo=82.9 * 1.0684
parameters rend_rnodrpo=1.586e-05 * 1.202
parameters dxl_rnodrpo=0e-06 - 0e-06
parameters x_dxw_rnodrpo=1
parameters r_rpodrpo=128.2 * 1.0696
parameters rend_rpodrpo=2.850e-05 * 1.175
parameters dxl_rpodrpo=0e-06 - 0e-06
parameters x_dxw_rpodrpo=1
parameters r_rnpo1rpo=322.5 * 1.0698
parameters rend_rnpo1rpo=1.050e-04 * 1.2105
parameters dxl_rnpo1rpo=0e-06 - 0e-06
parameters x_dxw_rnpo1rpo=1
parameters r_rppo1rpo=350.8 * 1.0712
parameters rend_rppo1rpo=1.300e-04 * 1.1705
parameters dxl_rppo1rpo=0e-06 - 0e-06
parameters x_dxw_rppo1rpo=1
parameters r_rppolyhri=1026.123930 * 1.132
parameters rend_rppolyhri=1.203938e-04 * 1.375
parameters dxl_rppolyhri=0e-6 + 0e-6
parameters x_dxw_rppolyhri=1
parameters r_rppolyhri3k=3110 * 1.135
parameters rend_rppolyhri3k=6.950e-05 * 1.4215
parameters x_dxl_rppolyhri3k=1
parameters x_dxw_rppolyhri3k=1
parameters r_nodrpo_pure5v=83.050 * 1.07
parameters rend_nodrpo_pure5v=2.522e-05 * 1.33
parameters dxl_nodrpo_pure5v=0 + 0.0
parameters x_dxw_nodrpo_pure5v=1
parameters r_podrpo_pure5v=120.229 * 1.07
parameters rend_podrpo_pure5v=4.1589e-05 * 1.095
parameters dxl_podrpo_pure5v=0 + 0.0
parameters x_dxw_podrpo_pure5v=1
parameters r_npolyrpo_pure5v=355.35 * 1.137
parameters rend_npolyrpo_pure5v=9.561e-05 * 1.15
parameters dxl_npolyrpo_pure5v=0 + 0.0
parameters x_dxw_npolyrpo_pure5v=1
parameters r_ppolyrpo_pure5v=335 * 1.09
parameters rend_ppolyrpo_pure5v=0.00017 * 1.185
parameters dxl_ppolyrpo_pure5v=0 + 0.0
parameters x_dxw_ppolyrpo_pure5v=1
parameters r_rnwsti=963.6 * 1.139
parameters rend_rnwsti=250e-6 * 1.17
parameters r_rnwsti_pure5v=1070 * 1.28
parameters rend_rnwsti_pure5v=380e-6 * 1.3
parameters r_rnwod=416 * 1.11
parameters rend_rnwod=205e-6 * 1.125
parameters r_rnwod_pure5v=586 * 1.11
parameters rend_rnwod_pure5v=250e-6 * 1.125
 
include "cmn018_gp2a_5v_v1d4.scs" section=res
endsection ss_res
 
 
 
// *************************** Fast corner of resistor ***********************************

section ff_res
include "cmn018_gp2a_5v_v1d4.scs" section=setup_res
parameters par_res=0
parameters r_rnod=7.28 * 0.6334
parameters r_rnodw=7.28 * 0.6334
parameters r_rpod=7.49 * 0.6133
parameters r_rpodw=7.49 * 0.6133
parameters r_rnpo1=8.23 * 0.7463
parameters r_rnpo1w=8.23 * 0.7463
parameters r_rppo1=8.41 * 0.6836
parameters r_rppo1w=8.41 * 0.6836
parameters r_rm1=0.078 - 0.023
parameters r_rm2=0.078 - 0.023
parameters r_rm3=0.078 - 0.023
parameters r_rm4=0.078 - 0.023
parameters r_rm5=0.078 - 0.023
parameters r_rm6=0.036 - 0.009
parameters r_rmt=0.0178 - 0.00623
parameters r_rmu_40k=0.0062 - 0.001
parameters r_rmu_33k=0.0054 - 0.0016
parameters r_rmap=0.0105 - 0.0042
parameters r_rnodrpo=82.9 * 0.9316
parameters rend_rnodrpo=1.586e-05 * 0.798
parameters dxl_rnodrpo=0e-06 + 0.045e-06
parameters x_dxw_rnodrpo=-1
parameters r_rpodrpo=128.2 * 0.9304
parameters rend_rpodrpo=2.850e-05 * 0.825
parameters dxl_rpodrpo=0e-06 + 0.0575e-06
parameters x_dxw_rpodrpo=-1
parameters r_rnpo1rpo=322.5 * 0.9302
parameters rend_rnpo1rpo=1.050e-04 * 0.7895
parameters dxl_rnpo1rpo=0e-06 + 0.029e-06
parameters x_dxw_rnpo1rpo=-1
parameters r_rppo1rpo=350.8 * 0.9288
parameters rend_rppo1rpo=1.300e-04 * 0.8295
parameters dxl_rppo1rpo=0e-06 + 0.0265e-06
parameters x_dxw_rppo1rpo=-1
parameters r_rppolyhri=1026.123930 * 0.872
parameters rend_rppolyhri=1.203938e-04 * 0.55
parameters dxl_rppolyhri=0e-6 + 0e-6
parameters x_dxw_rppolyhri=-1
parameters r_rppolyhri3k=3110 * 0.885
parameters rend_rppolyhri3k=6.950e-05 * 0.5785
parameters x_dxl_rppolyhri3k=-1
parameters x_dxw_rppolyhri3k=-1
parameters r_nodrpo_pure5v=83.050 * 0.94
parameters rend_nodrpo_pure5v=2.522e-05 * 0.5
parameters dxl_nodrpo_pure5v=0.0e-06 + 0.0e-06
parameters x_dxw_nodrpo_pure5v=-1
parameters r_podrpo_pure5v=120.229 * 0.935
parameters rend_podrpo_pure5v=4.1589e-05 * 0.88
parameters dxl_podrpo_pure5v=0.0e-06 + 0.0e-06
parameters x_dxw_podrpo_pure5v=-1
parameters r_npolyrpo_pure5v=355.35 * 0.87
parameters rend_npolyrpo_pure5v=9.561e-05 * 0.83
parameters dxl_npolyrpo_pure5v=0.0e-06 + 0.0e-06
parameters x_dxw_npolyrpo_pure5v=-1
parameters r_ppolyrpo_pure5v=335 * 0.925
parameters rend_ppolyrpo_pure5v=0.00017 * 0.85
parameters dxl_ppolyrpo_pure5v=0.0e-06 + 0.0e-06
parameters x_dxw_ppolyrpo_pure5v=-1
parameters r_rnwsti=963.6 * 0.861
parameters rend_rnwsti=250e-6 * 0.83
parameters r_rnwsti_pure5v=1070 * 0.72
parameters rend_rnwsti_pure5v=380e-6 * 0.7
parameters r_rnwod=416 * 0.89
parameters rend_rnwod=205e-6 * 0.88
parameters r_rnwod_pure5v=586 * 0.89
parameters rend_rnwod_pure5v=250e-6 * 0.88
 
include "cmn018_gp2a_5v_v1d4.scs" section=res
endsection ff_res
 
 
 
 
 

section res
// ************************************
//        2T Resister model           *
// ************************************
// *************************** N+ OD w/i silicide W>2um resistor model ***********************************
subckt rnod ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01142 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnod * (1 + factmis) dw=-0.0858u pvc2w=2.38e-013 * (min(w 
+ * factor * 1e6,10)) * (min(w * factor * 1e6,10)) - 1.50e-13 * (min(w * factor 
+ * 1e6,10)) + 7.45e-12 ptc1=3.35e-3 ptc2=4.31e-7 pvc1=4.19e-08 pvc2=pvc2w * (1.0 
+ - 7.78e-03 * (pt - 25.0) + 5.23e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp tfac=1.0 
+ + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf * l * factor 
+ / (w * factor - dw) * tfac 
r1 ( n1 n2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / l / factor) 
+ + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)),rmain * 1.5),rmain 
+ / 2)
ends rnod
 
// *************************** N+ OD w/i silicide 0.22um<W<2um ***********************************
subckt rnodw ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01142 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnodw * (1 + factmis) dw=-0.0858u pvc2w=2.38e-013 * (min(w 
+ * factor * 1e6,10)) * (min(w * factor * 1e6,10)) - 1.50e-13 * (min(w * factor 
+ * 1e6,10)) + 7.45e-12 ptc1=3.35e-3 ptc2=4.31e-7 pvc1=4.19e-08 pvc2=pvc2w * (1.0 
+ - 7.78e-03 * (pt - 25.0) + 5.23e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp tfac=1.0 
+ + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf * l * factor 
+ / (w * factor - dw) * tfac 
r1 ( n1 n2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / l / factor) 
+ + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)),rmain * 1.5),rmain 
+ / 2)
ends rnodw
 
// *************************** P+ OD w/i silicide W>2um ***********************************
subckt rpod ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01604 * geo_fac * par_res 
+ * mismatchflag rsh=r_rpod * (1 + factmis) dw=-0.087u pvc2w= - 9.03e-014 * (min(w 
+ * factor * 1e6,10)) * (min(w * factor * 1e6,10)) + 4.08e-12 * (min(w * factor 
+ * 1e6,10)) + 3.79e-12 ptc1=3.38e-3 ptc2=4.31e-7 pvc1=8.55e-09 pvc2=pvc2w * (1.0 
+ - 5.43e-03 * (pt - 25.0) + 2.58e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp tfac=1.0 
+ + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf * l * factor 
+ / (w * factor - dw) * tfac 
r1 ( n1 n2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / l / factor) 
+ + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)),rmain * 1.5),rmain 
+ / 2)
ends rpod
 
// *************************** P+ OD w/i silicide 0.22um<W<2um ***********************************
subckt rpodw ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01604 * geo_fac * par_res 
+ * mismatchflag rsh=r_rpodw * (1 + factmis) dw=-0.087u pvc2w= - 9.03e-014 * (min(w 
+ * factor * 1e6,10)) * (min(w * factor * 1e6,10)) + 4.08e-12 * (min(w * factor 
+ * 1e6,10)) + 3.79e-12 ptc1=3.38e-3 ptc2=4.31e-7 pvc1=8.55e-09 pvc2=pvc2w * (1.0 
+ - 5.43e-03 * (pt - 25.0) + 2.58e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp tfac=1.0 
+ + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf * l * factor 
+ / (w * factor - dw) * tfac 
r1 ( n1 n2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / l / factor) 
+ + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)),rmain * 1.5),rmain 
+ / 2)
ends rpodw
 
// *************************** N+ Poly w/i silicide W>2um ***********************************
subckt rnpo1 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.0101 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnpo1 * (1 + factmis) dw=-0.031u pvc2w= - 1.52e-012 * (min(w 
+ * factor * 1e6,10)) * (min(w * factor * 1e6,10)) + 2.17e-11 * (min(w * factor 
+ * 1e6,10)) + 2.34e-11 ptc1=3.1e-3 ptc2=2.66e-7 pvc1=-4.32e-9 pvc2=pvc2w * (1.0 
+ - 7.07e-03 * (pt - 25.0) + 3.02e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp tfac=1.0 
+ + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf * l * factor 
+ / (w * factor - dw) * tfac 
r1 ( n1 n2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / l / factor) 
+ + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)),rmain * 1.5),rmain 
+ / 2)
ends rnpo1
 
// *************************** N+ Poly w/i silicide 0.18um<W<2um ***********************************
subckt rnpo1w ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.0101 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnpo1w * (1 + factmis) dw=-0.031u pvc2w= - 1.52e-012 * (min(w 
+ * factor * 1e6,10)) * (min(w * factor * 1e6,10)) + 2.17e-11 * (min(w * factor 
+ * 1e6,10)) + 2.34e-11 ptc1=3.05e-3 ptc2=2.66e-7 pvc1=-4.32e-9 pvc2=pvc2w * (1.0 
+ - 6.1e-03 * (pt - 25.0) + 2.44e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp tfac=1.0 
+ + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf * l * factor 
+ / (w * factor - dw) * tfac 
r1 ( n1 n2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / l / factor) 
+ + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)),rmain * 1.5),rmain 
+ / 2)
ends rnpo1w
 
// *************************** P+ Poly w/i silicide W>2um ***********************************
subckt rppo1 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.0132 * geo_fac * par_res 
+ * mismatchflag rsh=r_rppo1 * (1 + factmis) dw=-0.013u pvc2w= - 1.58e-012 * (min(w 
+ * factor * 1e6,10)) * (min(w * factor * 1e6,10)) + 2.22e-11 * (min(w * factor 
+ * 1e6,10)) + 2.02e-11 ptc1=2.98e-3 ptc2=5.01e-7 pvc1=-4.2e-09 pvc2=pvc2w * (1.0 
+ - 5.83e-03 * (pt - 25.0) + 2.27e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp tfac=1.0 
+ + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf * l * factor 
+ / (w * factor - dw) * tfac 
r1 ( n1 n2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / l / factor) 
+ + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)),rmain * 1.5),rmain 
+ / 2)
ends rppo1
 
// *************************** P+ Poly w/i silicide 0.18um<W<2um ***********************************
subckt rppo1w ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.0132 * geo_fac * par_res 
+ * mismatchflag rsh=r_rppo1w * (1 + factmis) dw=-0.013u pvc2w= - 1.58e-012 * (min(w 
+ * factor * 1e6,10)) * (min(w * factor * 1e6,10)) + 2.22e-11 * (min(w * factor 
+ * 1e6,10)) + 2.02e-11 ptc1=2.98e-3 ptc2=5.01e-7 pvc1=-4.2e-09 pvc2=pvc2w * (1.0 
+ - 5.83e-03 * (pt - 25.0) + 2.27e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp tfac=1.0 
+ + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf * l * factor 
+ / (w * factor - dw) * tfac 
r1 ( n1 n2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / l / factor) 
+ + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)),rmain * 1.5),rmain 
+ / 2)
ends rppo1w
// *************************** Metal 1 with W/S=0.23/0.23 ***********************************
subckt rm1 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm1 dw=0.03u ptc1=3.43e-3 ptc2=-1.08e-6 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm1
// *************************** Metal 2 with W/S=0.28/0.28 ***********************************
subckt rm2 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm2 dw=0.03u ptc1=3.43e-3 ptc2=-1.08e-6 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm2
// *************************** Metal 3 with W/S=0.28/0.28 ***********************************
subckt rm3 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm3 dw=0.03u ptc1=3.43e-3 ptc2=-1.08e-6 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm3
// *************************** Metal 4 with W/S=0.28/0.28 ***********************************
subckt rm4 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm4 dw=0.03u ptc1=3.43e-3 ptc2=-1.08e-6 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm4
// *************************** Metal 5 with W/S=0.28/0.28 ***********************************
subckt rm5 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm5 dw=0.03u ptc1=3.43e-3 ptc2=-1.08e-6 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm5
// *************************** Metal 6 with W/S=0.44/0.46 ***********************************
subckt rm6 ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rm6 dw=0.04u ptc1=3.60e-3 ptc2=-1.16e-7 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rm6
 
subckt rmt ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rmt dw=0.04u ptc1=3.60e-3 ptc2=-1.16e-7 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rmt
 
subckt rmu_40k ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rmu_40k dw=0.05u ptc1=0 ptc2=0 pvc1=0 
+ pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rmu_40k
 
subckt rmu_33k ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rmu_33k dw=0u ptc1=3.41e-3 ptc2=4.08e-6 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rmu_33k
 
subckt rmap ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 rsh=r_rmap dw=0u ptc1=3.89e-3 ptc2=-1.5e-7 
+ pvc1=0 pvc2=0 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n1 n2 ) resistor r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rmap
 
// *************************** N+ OD w/o silicide 2um<=W ***********************************
subckt rnodrpo ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.03420 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnodrpo * (1 + factmis) rend0=rend_rnodrpo * (1 + factmis) 
+ dl=0.000e+00 + dxl_rnodrpo dw= - 4.470e-08 - 3.0103e-07 * (pow(0.7592,x_dxw_rnodrpo) 
+ - 1) pt=temp pvce1=0.0189 pvce2=3.92 pvce3=0.182 ptce1=7.691e-04 ptce2=-1.678e-06 
+ pvcp1=-0.299 pvcp2=-0.00000764 pvcp3=2.449 ptcp1=1.548e-03 ptcp2=5.250e-07 tface=1.0 
+ + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * 
+ (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n1 3 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rpure ( 3 4 ) resistor r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp 
+ * (1 + pvcp1 * (tanh(pvcp2 * abs(v(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3)))
rend2 ( 4 n2 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
ends rnodrpo
 
// *************************** N+ Poly w/o silicide 2um<W ***********************************
subckt rnpo1rpo ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.02506 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnpo1rpo * (1 + factmis) rend0=rend_rnpo1rpo * (1 + factmis) 
+ dl=0.000e+00 + dxl_rnpo1rpo dw=8.700e-08 - 2.7819e-07 * (pow(0.7649,x_dxw_rnpo1rpo) 
+ - 1) pt=temp pvce1=0.5 pvce2=2.5 pvce3=1.432 ptce1=-1.784e-03 ptce2=-3.950e-07 
+ pvcp1=-0.117 pvcp2=0.0000047 pvcp3=-1.88 ptcp1=-1.456e-03 ptcp2=2.679e-06 tface=1.0 
+ + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * 
+ (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n1 3 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rpure ( 3 4 ) resistor r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp 
+ * (1 + pvcp1 * (tanh(pvcp2 * abs(v(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3)))
rend2 ( 4 n2 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
ends rnpo1rpo
 
// *************************** P+ OD w/o silicide 2um<=W ***********************************
subckt rpodrpo ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01008 * geo_fac * par_res 
+ * mismatchflag rsh=r_rpodrpo * (1 + factmis) rend0=rend_rpodrpo * (1 + factmis) 
+ dl=0.000e+00 + dxl_rpodrpo dw= - 2.050e-08 - 3.8619e-07 * (pow(0.80762,x_dxw_rpodrpo) 
+ - 1) pt=temp pvce1=0.3 pvce2=-3.6 pvce3=0.01 ptce1=-3.050e-04 ptce2=1.100e-06 
+ pvcp1=-0.6968 pvcp2=-0.000001807 pvcp3=2.1 ptcp1=1.423e-03 ptcp2=8.632e-07 tface=1.0 
+ + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * 
+ (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n1 3 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rpure ( 3 4 ) resistor r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp 
+ * (1 + pvcp1 * (tanh(pvcp2 * abs(v(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3)))
rend2 ( 4 n2 ) resistor r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
ends rpodrpo
 
// *************************** P+ Poly w/o silicide 2um<W ***********************************
subckt rppo1rpo ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01046 * geo_fac * par_res 
+ * mismatchflag rsh=r_rppo1rpo * (1 + factmis) rendsh=2 * rend_rppo1rpo * (1 + 
+ factmis) * 1e6 dl=0.000e+00 + dxl_rppo1rpo dw_etch=0u - 2.5041e-07 * (pow(0.7488,x_dxw_rppo1rpo) 
+ - 1) dw_emp=3.400e-08 dw_empend=0 dw=(dw_etch + dw_emp) * 1e6 dwend=0 jc1_0=0.103428536300757 
+ jc1_w=0.0237600720950873 jc1_n=0.0005981670378054 jc1end_0=1.80682127611015 jc1end_w=0.68716151233078 
+ tc1_0=-0.000252990022695571 tc1_w=6.3169024328277e-06 tc2_0=6.75735736450397e-07 
+ tc2_w=-6.97977253756941e-10 tc1end_0=-0.00164627865883391 tc1end_w=9.75942711452446e-06 
+ tc2end_0=4.21852469059498e-07 tc2end_w=-2.33978426054113e-09 jct_0=-0.00509298249983379 
+ jct_w=-0.00015629755371274 jctend_0=0.000981261188626716 jctend_w=0.000325620892259473 
+ delta_t=temp - 25 lum=l * factor * 1e6 wum=w * factor * 1e6 nsqr=l/w tc1=tc1_0 
+ + tc1_w * min(wum,10) tc2=tc2_0 + tc2_w * min(wum,10) tc1end=tc1end_0 + tc1end_w 
+ * min(wum,10) tc2end=tc2end_0 + tc2end_w * min(wum,10) jct=jct_0 + jct_w * min(wum,10) 
+ jctend=jctend_0 + jctend_w * min(wum,10) jc1=max(0,(jc1_0 + jc1_w * min(wum,10) 
+ + jc1_n * min(nsqr,73)) * (1 + jct * delta_t) / (lum - dl) / (lum - dl)) jc1_r=jc1 
+ jc1end=max(0,(jc1end_0 + jc1end_w * min(wum,10)) * (1 + jctend * delta_t)) jc1end_r=jc1end 
+ tfac=1 + tc1 * delta_t + tc2 * delta_t * delta_t tfacend=1 + tc1end * delta_t 
+ + tc2end * delta_t * delta_t rendo=rendsh / mf / (wum - dwend) * tfacend ro=rsh 
+ / mf * (lum - dl) / (wum - dw) * tfac 
rend ( n1 2 ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(n1,2) * v(n1,2))),rendo 
+ * 1.5),rendo / 2)
rmain ( 2 n2 ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(2,n2) * v(2,n2))),ro 
+ * 1.5),ro / 2)
 
ends rppo1rpo
 
// *************************** P- Poly w/o silicide ***********************************
subckt rppolyhri ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.00964 * geo_fac * par_res 
+ * mismatchflag rsh=r_rppolyhri * (1 + factmis) rendsh=2 * rend_rppolyhri * 1e6 
+ * (1 + factmis) dw_etch=0u - 3.9286e-08 * (pow(0.44,x_dxw_rppolyhri) - 1) dw_emp=6.5410714883522e-08 
+ dw_empend=7.410714883522e-10 dl_etch=0 dw=(dw_etch + dw_emp) * 1e6 dwend=(dw_etch 
+ + dw_empend) * 1e6 dl=(dl_etch + dxl_rppolyhri) * 1e6 jc1_0=0.1474037106889946 
+ jc1_w=0.0400847859662231 jc1_n=0.000964257603206478 jc1end_0=5.878327431421787 
+ jc1end_w=2.65607312261631 tc1_0=-0.00103412157111652 tc1_w=1.10638460995948e-05 
+ tc2_0=2.50172779429575e-06 tc2_w=-7.29824957952402e-08 tc1end_0=-0.000530197650596438 
+ tc1end_w=-0.000148415177260185 tc2end_0=-1.40888462983242e-06 tc2end_w=8.23396549335135e-07 
+ jct_0=-0.00341305960400095 jct_w=5.19508920284451e-05 jctend_0=-0.00469373756335246 
+ jctend_w=0.00101066163029796 delta_t=temp - 25 lum=l * factor * 1e6 wum=w * 
+ factor * 1e6 nsqr=l/w tc1=tc1_0 + tc1_w * min(wum,10) tc2=tc2_0 + tc2_w * min(wum,10) 
+ tc1end=tc1end_0 + tc1end_w * min(wum,10) tc2end=tc2end_0 + tc2end_w * min(wum,10) 
+ jct=jct_0 + jct_w * min(wum,10) jctend=jctend_0 + jctend_w * min(wum,10) jc1=(jc1_0 
+ + jc1_w * min(wum,10) + jc1_n * min(nsqr,20)) * (1 + jct * delta_t) / (lum - dl) 
+ / (lum - dl) jc1_r=jc1 jc1end=max(0,(jc1end_0 + jc1end_w * min(wum,10)) * (1 + 
+ jctend * delta_t)) jc1end_r=jc1end tfac=1 + tc1 * delta_t + tc2 * delta_t * delta_t 
+ tfacend=1 + tc1end * delta_t + tc2end * delta_t * delta_t rendo=rendsh / mf / 
+ (wum - dwend) * tfacend ro=rsh / mf * (lum - dl) / (wum - dw) * tfac 
rend ( n1 1 ) resistor r=max(min(rendo / 2 * (3 - 1 / (1 + jc1end_r * v(n1,1) * v(n1,1))),rendo 
+ * 1.5),rendo / 2)
rmain ( 1 n2 ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(1,n2) * v(1,n2))),ro 
+ * 1.5),ro / 2)
ends rppolyhri
 
// **********************************     P-POLY w/o silicide resistor(3K)    
//  ***********************************
subckt rppolyhri3k ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.0180 * geo_fac * par_res 
+ * mismatchflag rsh=r_rppolyhri3k * (1 + factmis) rendsh=rend_rppolyhri3k * 1e6 
+ * (1 + factmis) dw=7.3e-02 + ( - 3.5315e-08 * (pow(0.30625,x_dxw_rppolyhri3k) 
+ - 1)) * 1e6 dwend=0 dl=1.50e-01 + ( - 1.8e-7 * (pow(1.1111,x_dxl_rppolyhri3k) 
+ - 1)) * 1e6 jc1_0=0.0284541776598384 jc1_w=0.0552178046415412 * 1.2 jc1_n=0.000714344378379032 
+ * 2.5 jc1end_0=0 jc1end_w=0 tc1_0=-0.002016610001954663 tc1_w=1.80006103761493e-05 
+ tc2_0=5.06026391020496e-06 tc2_w=-1.21111777945279e-07 tc1end_0=0 tc1end_w=0 tc2end_0=0 
+ tc2end_w=0 jct_0=-0.00386214585793815 jct_w=0.00019185053193552 jctend_0=0 jctend_w=0 
+ delta_t=temp - 25 lum=l * factor * 1e6 wum=w * factor * 1e6 nsqr=l/w tc1=tc1_0 
+ + tc1_w * wum tc2=tc2_0 + tc2_w * wum tc1end=tc1end_0 + tc1end_w * wum tc2end=tc2end_0 
+ + tc2end_w * wum jct=jct_0 + jct_w * wum jctend=jctend_0 + jctend_w * wum jc1=max(0,(jc1_0 
+ + jc1_w * wum + jc1_n * nsqr) * (1 + jct * delta_t) / (lum - dl) / (lum - dl)) 
+ jc1end=max(0,(jc1end_0 + jc1end_w * wum) * (1 + jctend * delta_t)) tfac=1 + tc1 
+ * delta_t + tc2 * delta_t * delta_t tfacend=1 + tc1end * delta_t + tc2end * delta_t 
+ * delta_t rendo=rendsh / mf / (wum - dwend) * tfacend ro=rsh / mf * (lum - dl) 
+ / (wum - dw) * tfac 
rend ( n1 1 ) resistor r=max(min(rendo / 2 * (3 - 1 / (1 + jc1end * v(n1,1) * v(n1,1))),rendo 
+ * 1.5),rendo / 2)
rmain ( 1 n2 ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1 * v(1,n2) * v(1,n2))),ro 
+ * 1.5),ro / 2)
ends rppolyhri3k
 
// *************************** N+ OD w/o silicide 2um<=W (pure5V)***********************************
subckt rnodrpo_pure5v ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.0345 * geo_fac * par_res 
+ * mismatchflag rsh=r_nodrpo_pure5v * (1 + factmis) rendsh=2 * rend_nodrpo_pure5v 
+ * 1e6 * (1 + factmis) dw_etch=0u - 2.3333e-07 * (pow(0.7,x_dxw_nodrpo_pure5v) 
+ - 1) dw_emp=-7.04e-08 dw_empend=-1.29859012784265e-07 dl_etch=0 dw=(dw_etch + 
+ dw_emp) * 1e6 dwend=(dw_etch + dw_empend) * 1e6 dl=(dl_etch + dxl_nodrpo_pure5v) 
+ * 1e6 jc1_0=0.26049641179018 jc1_w=0.338753336333001 jc1_n=0.0115470183520801 
+ jc1end_0=0.482123799537825 jc1end_w=0.0465075945675371 tc1_0=0.00163760188660371 
+ tc1_w=4.869908308429e-06 tc2_0=-5.1547590573148e-07 tc2_w=-1.66380122167674e-08 
+ tc1end_0=0.000678492619996571 tc1end_w=0.00013178484793306 tc2end_0=-1.88756918539424e-07 
+ tc2end_w=-7.42454642097019e-07 jct_0=-0.000221973003336103 jct_w=0.000308757232255487 
+ jctend_0=-0.0523812972984853 jctend_w=0.076695898710281 delta_t=temp - 25 lum=l 
+ * factor * 1e6 wum=w * factor * 1e6 nsqr=l/w tc1=tc1_0 + tc1_w * min(wum,10) tc2=tc2_0 
+ + tc2_w * min(wum,10) tc1end=tc1end_0 + tc1end_w * min(wum,10) tc2end=tc2end_0 
+ + tc2end_w * min(wum,10) jct=jct_0 + jct_w * min(wum,10) jctend=jctend_0 + jctend_w 
+ * min(wum,10) jc1=max(0,(jc1_0 + jc1_w * min(wum,10) + jc1_n * min(nsqr,73)) * 
+ (1 + jct * delta_t) / (lum - dl) / (lum - dl)) jc1_r=jc1 jc1end=max(0,(jc1end_0 
+ + jc1end_w * min(wum,10)) * (1 + jctend * delta_t)) jc1end_r=jc1end tfac=1 + tc1 
+ * delta_t + tc2 * delta_t * delta_t tfacend=1 + tc1end * delta_t + tc2end * delta_t 
+ * delta_t rendo=rendsh / mf / (wum - dwend) * tfacend ro=rsh / mf * (lum - dl) 
+ / (wum - dw) * tfac 
rend ( n1 1 ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(n1,1) * v(n1,1))),rendo 
+ * 1.5),rendo / 2)
rmain ( 1 n2 ) resistor r=max(min(ro / 2 * (3 - 1 / (1 + jc1_r * v(1,n2) * v(1,n2))),ro 
+ * 1.5),ro / 2)
ends rnodrpo_pure5v
// *************************** P+ OD w/o silicide 2um<=W (pure5V)***********************************
subckt rpodrpo_pure5v ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.009907 * geo_fac * par_res 
+ * mismatchflag rsh=r_podrpo_pure5v * (1 + factmis) rendsh=2 * rend_podrpo_pure5v 
+ * 1e6 * (1 + factmis) dw_etch=0u - 1.7727e-07 * (pow(0.5769,x_dxw_podrpo_pure5v) 
+ - 1) dw_emp=-4.00e-08 dw_empend=-8.27061147481514e-08 dl_etch=0 dw=(dw_etch + 
+ dw_emp) * 1e6 dwend=(dw_etch + dw_empend) * 1e6 dl=(dl_etch + dxl_podrpo_pure5v) 
+ * 1e6 jc1_0=0.09618866202628 jc1_w=0.226049398240571 jc1_n=0.00861902964341637 
+ jc1end_0=-2.96409728163819 jc1end_w=2.72971278363163 tc1_0=0.00144731708903961 
+ tc1_w=1.57298124939104e-05 tc2_0=-2.06130245947975e-07 tc2_w=-1.15247737940013e-08 
+ tc1end_0=-0.000119488998923866 tc1end_w=1.45662867931858e-05 tc2end_0=-5.42849184541314e-07 
+ tc2end_w=1.94384271799479e-07 jct_0=0.00151710515394783 jct_w=2.68954319339542e-05 
+ jctend_0=0.00159368183931327 jctend_w=0.00577596003187178 delta_t=temp - 25 
+ lum=l * factor * 1e6 wum=w * factor * 1e6 nsqr=l/w tc1=tc1_0 + tc1_w * min(wum,10) 
+ tc2=tc2_0 + tc2_w * min(wum,10) tc1end=tc1end_0 + tc1end_w * min(wum,10) tc2end=tc2end_0 
+ + tc2end_w * min(wum,10) jct=jct_0 + jct_w * min(wum,10) jctend=jctend_0 + jctend_w 
+ * min(wum,10) jc1=max(0,(jc1_0 + jc1_w * min(wum,10) + jc1_n * min(nsqr,73)) * 
+ (1 + jct * delta_t) / (lum - dl) / (lum - dl)) jc1_r=jc1 jc1end=max(0,(jc1end_0 
+ + jc1end_w * min(wum,10)) * (1 + jctend * delta_t)) jc1end_r=jc1end tfac=1 + tc1 
+ * delta_t + tc2 * delta_t * delta_t tfacend=1 + tc1end * delta_t + tc2end * delta_t 
+ * delta_t rendo=rendsh / mf / (wum - dwend) * tfacend ro=rsh / mf * (lum - dl) 
+ / (wum - dw) * tfac 
rend ( n1 1 ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(n1,1) * v(n1,1))),rendo 
+ * 1.5),rendo / 2)
rmain ( 1 n2 ) resistor r=max(min(ro / 2 * (3 - 1 / (1 + jc1_r * v(1,n2) * v(1,n2))),ro 
+ * 1.5),ro / 2)
ends rpodrpo_pure5v
// *************************** N+ POLY w/o silicide 2um<=W (pure5V)***********************************
subckt rnpo1rpo_pure5v ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.0302 * geo_fac * par_res 
+ * mismatchflag rsh=r_npolyrpo_pure5v * (1 + factmis) rendsh=2 * rend_npolyrpo_pure5v 
+ * 1e6 * (1 + factmis) dw_etch=0u - 8.8421e-08 * (pow(0.525,x_dxw_npolyrpo_pure5v) 
+ - 1) dw_emp=8.84e-08 dw_empend=6.24351809003062e-08 dl_etch=0 dw=(dw_etch + dw_emp) 
+ * 1e6 dwend=(dw_etch + dw_empend) * 1e6 dl=(dl_etch + dxl_npolyrpo_pure5v) * 1e6 
+ jc1_0=0.593574049300358 jc1_w=0.208476151328853 jc1_n=0.009156387660113 jc1end_0=-0.884382207504105 
+ jc1end_w=1.74501073484064 tc1_0=-0.0016401156446971 tc1_w=1.1650783389784e-06 
+ tc2_0=4.26975595787514e-06 tc2_w=1.23630864199603e-08 tc1end_0=-0.00224927008416115 
+ tc1end_w=0.000463561787547606 tc2end_0=3.1723812326026e-06 tc2end_w=-1.00922530619054e-08 
+ jct_0=-0.00252818279600855 jct_w=-1.15641997879775e-06 jctend_0=0.000762325032321053 
+ jctend_w=-0.00297638541249764 delta_t=temp - 25 lum=l * factor * 1e6 wum=w * 
+ factor * 1e6 nsqr=l/w tc1=tc1_0 + tc1_w * min(wum,10) tc2=tc2_0 + tc2_w * min(wum,10) 
+ tc1end=tc1end_0 + tc1end_w * min(wum,10) tc2end=tc2end_0 + tc2end_w * min(wum,10) 
+ jct=jct_0 + jct_w * min(wum,10) jctend=jctend_0 + jctend_w * min(wum,10) jc1=max(0,(jc1_0 
+ + jc1_w * min(wum,10) + jc1_n * min(nsqr,73)) * (1 + jct * delta_t) / (lum - dl) 
+ / (lum - dl)) jc1_r=jc1 jc1end=max(0,(jc1end_0 + jc1end_w * min(wum,10)) * (1 
+ + jctend * delta_t)) jc1end_r=jc1end tfac=1 + tc1 * delta_t + tc2 * delta_t * 
+ delta_t tfacend=1 + tc1end * delta_t + tc2end * delta_t * delta_t rendo=rendsh 
+ / mf / (wum - dwend) * tfacend ro=rsh / mf * (lum - dl) / (wum - dw) * tfac 
rend ( n1 1 ) resistor r=max(min(rendo / 2 * (3 - 1 / (1 + jc1end_r * v(n1,1) * v(n1,1))),rendo 
+ * 1.5),rendo / 2)
rmain ( 1 n2 ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(1,n2) * v(1,n2))),ro 
+ * 1.5),ro / 2)
ends rnpo1rpo_pure5v
// *************************** P+ POLY w/o silicide 2um<=W (pure5V)***********************************
subckt rppo1rpo_pure5v ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.01099 * geo_fac * par_res 
+ * mismatchflag rsh=r_ppolyrpo_pure5v * (1 + factmis) rendsh=2 * rend_ppolyrpo_pure5v 
+ * 1e6 * (1 + factmis) dw_etch=0u - 7.7209e-08 * (pow(0.4819,x_dxw_ppolyrpo_pure5v) 
+ - 1) dw_emp=4.06e-08 dw_empend=-1.4e-7 dl_etch=0 dw=(dw_etch + dw_emp) * 1e6 dwend=(dw_etch 
+ + dw_empend) * 1e6 dl=(dl_etch + dxl_ppolyrpo_pure5v) * 1e6 jc1_0=0.0985942031265099 
+ jc1_w=0.0184775076507981 jc1_n=0.00097581646698633 jc1end_0=-0.336669969160045 
+ jc1end_w=0.92324003118435 tc1_0=-0.000226586518387305 tc1_w=5.17097297941423e-06 
+ tc2_0=1.02672749831316e-06 tc2_w=-8.68683719247075e-09 tc1end_0=-0.00174146670729387 
+ tc1end_w=3.78726466980252e-05 tc2end_0=2.07404932553801e-06 tc2end_w=-1.81953330651118e-07 
+ jct_0=-0.0065275554346074 jct_w=-0.0000966075915608463 jctend_0=0.00103744395916669 
+ jctend_w=0.00095892093794262 delta_t=temp - 25 lum=l * factor * 1e6 wum=w * 
+ factor * 1e6 nsqr=l/w tc1=tc1_0 + tc1_w * min(wum,10) tc2=tc2_0 + tc2_w * min(wum,10) 
+ tc1end=tc1end_0 + tc1end_w * min(wum,10) tc2end=tc2end_0 + tc2end_w * min(wum,10) 
+ jct=jct_0 + jct_w * min(wum,10) jctend=jctend_0 + jctend_w * min(wum,10) jc1=(jc1_0 
+ + jc1_w * min(wum,10) + jc1_n * min(nsqr,73)) * (1 + jct * delta_t) / (lum - dl) 
+ / (lum - dl) jc1_r=jc1 jc1end=(jc1end_0 + jc1end_w * min(wum,10)) * (1 + jctend 
+ * delta_t) jc1end_r=jc1end tfac=1 + tc1 * delta_t + tc2 * delta_t * delta_t tfacend=1 
+ + tc1end * delta_t + tc2end * delta_t * delta_t rendo=rendsh / mf / (wum - dwend) 
+ * tfacend ro=rsh / mf * (lum - dl) / (wum - dw) * tfac 
rend ( n1 1 ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(n1,1) * v(n1,1))),rendo 
+ * 1.5),rendo / 2)
rmain ( 1 n2 ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(1,n2) * v(1,n2))),ro 
+ * 1.5),ro / 2)
ends rppo1rpo_pure5v
 
// **********************************     N-well under STI resistor     ***********************************
subckt rnwsti ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.00385 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnwsti * (1 + factmis) dw=0.285e-6 pt=temp pvc1=(3.369e-08 
+ / (max(w * factor * 1e6,1.8)) + 8.881e-10) * (min(l * factor * 1e6,100)) + ( - 
+ 1.492e-07 / (max(w * factor * 1e6,1.8)) + 1.643e-07) pvc2=0 ptc1=3.006e-03 ptc2=7.0932e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf 
+ * l * factor / (w * factor - dw) * tfac rend=rend_rnwsti * (1 + factmis) 
rn1 ( n1 1 ) resistor r=rend / mf / (w * factor)
r1 ( 1 2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(2,1)) / l / factor) + pvc2 
+ * (v(2,1) / l / factor) * (v(2,1) / l / factor)),rmain * 1.5),rmain / 2)
rn2 ( 2 n2 ) resistor r=rend / mf / (w * factor)
ends rnwsti
// **********************************     N-well under STI resistor(Pure5V)   
//    ***********************************
subckt rnwsti_pure5v ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.00438 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnwsti_pure5v * (1 + factmis) dw=0.405e-6 - 0.05e-6 pt=temp 
+ pvc1=(3.369e-08 / (max(w * factor * 1e6,1.8)) + 8.881e-10) * (min(l * factor * 
+ 1e6,100)) + ( - 1.492e-07 / (max(w * factor * 1e6,1.8)) + 1.643e-07) pvc2=0 ptc1=3.5e-03 
+ ptc2=0.8e-05 ptc1_end=0 ptc2_end=-2e-5 tfacend=1.0 + ptc1_end * (pt - 25.0) + 
+ ptc2_end * (pt - 25.0) * (pt - 25.0) tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt 
+ - 25.0) * (pt - 25.0) rmain=rsh / mf * l * factor / (w * factor - dw) * tfac rend=rend_rnwsti_pure5v 
+ * (1 + factmis) 
rn1 ( n1 1 ) resistor r=rend / mf / (w * factor) * tfacend
r1 ( 1 2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(2,1)) / l / factor) + pvc2 
+ * (v(2,1) / l / factor) * (v(2,1) / l / factor)),rmain * 1.5),rmain / 2)
rn2 ( 2 n2 ) resistor r=rend / mf / (w * factor) * tfacend
ends rnwsti_pure5v
 
// **********************************     N-Well under OD resistor     ***********************************
subckt rnwod ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.00382 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnwod * (1 + factmis) dw=0.205u pt=temp pvc1=(2.293e-08 
+ / (max(w * factor * 1e6,1.8)) + 1.259e-09) * (min(l * factor * 1e6,100)) + ( - 
+ 5.381e-08 / (max(w * factor * 1e6,1.8)) + 6.448e-08) pvc2=0 ptc1=2.658e-03 ptc2=8.126e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf 
+ * l * factor / (w * factor - dw) * tfac rend=rend_rnwod * (1 + factmis) 
rn1 ( n1 1 ) resistor r=rend / mf / (w * factor + 0.5u)
r1 ( 1 2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(2,1)) / l / factor) + pvc2 
+ * (v(2,1) / l / factor) * (v(2,1) / l / factor)),rmain * 1.5),rmain / 2)
rn2 ( 2 n2 ) resistor r=rend / mf / (w * factor + 0.5u)
ends rnwod
 
// **********************************     N-Well under OD resistor (Pure5V)   
//   ***********************************
subckt rnwod_pure5v ( n1 n2 ) 
parameters l=1u w=1u factor=1 mf=1 mismatchflag=mismatchflag_res geo_fac=1 
+ / sqrt(mf * l * factor * w * factor * 1e12) factmis=0.00406 * geo_fac * par_res 
+ * mismatchflag rsh=r_rnwod_pure5v * (1 + factmis) dw=0.205u pt=temp pvc1=(2.293e-08 
+ / (max(w * factor * 1e6,1.8)) + 1.259e-09) * (min(l * factor * 1e6,100)) + ( - 
+ 5.381e-08 / (max(w * factor * 1e6,1.8)) + 6.448e-08) pvc2=0 ptc1=2.61e-03 ptc2=8.2e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf 
+ * l * factor / (w * factor - dw) * tfac rend=rend_rnwod_pure5v * (1 + factmis) 
rn1 ( n1 1 ) resistor r=rend / mf / (w * factor + 0.5u)
r1 ( 1 2 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(2,1)) / l / factor) + pvc2 
+ * (v(2,1) / l / factor) * (v(2,1) / l / factor)),rmain * 1.5),rmain / 2)
rn2 ( 2 n2 ) resistor r=rend / mf / (w * factor + 0.5u)
ends rnwod_pure5v
 
endsection res
 
 
 
 
 
// *************************************************************************
// 
//    3T RESISTANCE MODEL
// 
// *************************************************************************
// *************************** MC corner of resistor ***********************************

section mc_disres
include "cmn018_gp2a_5v_v1d4.scs" section=setup_disres
parameters par_res_dis=0
parameters a1_disres_sal=par1_disres * 3.1623 / 3.0
parameters a1_disres_rpo=par2_disres * 5.8363 / 3.1
parameters a2_disres_rpo=par3_disres * 0.96843 / 3.1
parameters a1_disres_nw=par4_disres * 2.8284 / 3
parameters r_rnod_dis=7.28 + (0.84396) * a1_disres_sal
parameters r_rnodw_dis=7.28 + (0.84396) * a1_disres_sal
parameters r_rpod_dis=7.49 + (0.91592) * a1_disres_sal
parameters r_rpodw_dis=7.49 + (0.91592) * a1_disres_sal
parameters r_rnpo1_dis=8.23 + (0.65988) * a1_disres_sal
parameters r_rnpo1w_dis=8.23 + (0.65988) * a1_disres_sal
parameters r_rppo1_dis=8.41 + (0.84145) * a1_disres_sal
parameters r_rppo1w_dis=8.41 + (0.84145) * a1_disres_sal
parameters r_rnodrpo_dis=82.9 + (0.97008) * a1_disres_rpo + (0.32457) * a2_disres_rpo
parameters rend_rnodrpo_dis=0.00001586 + (5.4808e-007) * a1_disres_rpo + (1.8338e-007) 
+ * a2_disres_rpo
parameters dxl_rnodrpo_dis=0e-06 + ( - 3.9726e-009) * a1_disres_rpo + (1.2105e-008) 
+ * a2_disres_rpo
parameters x_dxw_rnodrpo_dis=0e-06 + (0.17108) * a1_disres_rpo + (0.057239) * a2_disres_rpo
parameters r_rpodrpo_dis=128.2 + (1.5265) * a1_disres_rpo + (0.51074) * a2_disres_rpo
parameters rend_rpodrpo_dis=0.0000285 + (8.5325e-007) * a1_disres_rpo + (2.8548e-007) 
+ * a2_disres_rpo
parameters dxl_rpodrpo_dis=0e-06 + ( - 5.0762e-009) * a1_disres_rpo + (1.5468e-008) 
+ * a2_disres_rpo
parameters x_dxw_rpodrpo_dis=0e-06 + (0.17108) * a1_disres_rpo + (0.057239) * a2_disres_rpo
parameters r_rnpo1rpo_dis=322.5 + (3.8511) * a1_disres_rpo + (1.2888) * a2_disres_rpo
parameters rend_rnpo1rpo_dis=0.000105 + (3.7812e-006) * a1_disres_rpo + (1.265e-006) 
+ * a2_disres_rpo
parameters dxl_rnpo1rpo_dis=0e-06 + ( - 2.5602e-009) * a1_disres_rpo + (7.8013e-009) 
+ * a2_disres_rpo
parameters x_dxw_rnpo1rpo_dis=0e-06 + (0.17108) * a1_disres_rpo + (0.057239) * a2_disres_rpo
parameters r_rppo1rpo_dis=350.8 + (4.273) * a1_disres_rpo + (1.4296) * a2_disres_rpo
parameters rend_rppo1rpo_dis=0.000133 + (3.8084e-006) * a1_disres_rpo + ( - 5.1708e-007) 
+ * a2_disres_rpo
parameters dxl_rppo1rpo_dis=0e-06 + ( - 2.3394e-009) * a1_disres_rpo + (7.1287e-009) 
+ * a2_disres_rpo
parameters x_dxw_rppo1rpo_dis=0e-06 + (0.17108) * a1_disres_rpo + (0.057239) * a2_disres_rpo
parameters r_rppolyhri_dis=1026.123930 + (22.81) * a1_disres_rpo + (8.8562) * a2_disres_rpo
parameters rend_rppolyhri_dis=1.203938e-04 + (8.5209e-006) * a1_disres_rpo + (1.5501e-007) 
+ * a2_disres_rpo
parameters x_dxw_rppolyhri_dis=0e-6 + (0.17108) * a1_disres_rpo + (0.057239) * a2_disres_rpo
parameters r_rppolyhri3k_dis=3110 + (66.336) * a1_disres_rpo + (40.764) * a2_disres_rpo
parameters rend_rppolyhri3k_dis=0.0000695 + (5.0116e-006) * a1_disres_rpo + (1.6767e-006) 
+ * a2_disres_rpo
parameters x_dxl_rppolyhri3k_dis=0e-06 + (0.17108) * a1_disres_rpo + (0.057239) 
+ * a2_disres_rpo
parameters x_dxw_rppolyhri3k_dis=0e-06 + (0.17108) * a1_disres_rpo + (0.057239) 
+ * a2_disres_rpo
parameters r_nodrpo_pure5v_dis=83.050 + (0.92125) * a1_disres_rpo + (0.55617) * 
+ a2_disres_rpo
parameters rend_nodrpo_pure5v_dis=2.522e-05 + (1.8023e-006) * a1_disres_rpo + ( 
+ - 6.7698e-007) * a2_disres_rpo
parameters x_dxw_nodrpo_pure5v_dis=0e-06 + (0.17108) * a1_disres_rpo + (0.057239) 
+ * a2_disres_rpo
parameters r_podrpo_pure5v_dis=120.229 + (1.3867) * a1_disres_rpo + (0.64339) * 
+ a2_disres_rpo
parameters rend_podrpo_pure5v_dis=4.1589e-05 + (7.6772e-007) * a1_disres_rpo + ( 
+ - 5.3539e-008) * a2_disres_rpo
parameters x_dxw_podrpo_pure5v_dis=0e-06 + (0.17108) * a1_disres_rpo + (0.057239) 
+ * a2_disres_rpo
parameters r_npolyrpo_pure5v_dis=355.35 + (8.109) * a1_disres_rpo + (3.4558) * a2_disres_rpo
parameters rend_npolyrpo_pure5v_dis=9.561e-05 + (2.6224e-006) * a1_disres_rpo + 
+ (3.0665e-007) * a2_disres_rpo
parameters x_dxw_npolyrpo_pure5v_dis=0e-06 + (0.17108) * a1_disres_rpo + (0.057239) 
+ * a2_disres_rpo
parameters r_ppolyrpo_pure5v_dis=335 + (4.7144) * a1_disres_rpo + (3.0775) * a2_disres_rpo
parameters rend_ppolyrpo_pure5v_dis=0.00017 + (4.8552e-006) * a1_disres_rpo + (3.4008e-006) 
+ * a2_disres_rpo
parameters x_dxw_ppolyrpo_pure5v_dis=0e-06 + (0.17108) * a1_disres_rpo + (0.057239) 
+ * a2_disres_rpo
parameters dxl_rppolyhri_dis=0e-6
parameters dxl_nodrpo_pure5v_dis=0.0e-06
parameters dxl_podrpo_pure5v_dis=0.0e-06
parameters dxl_npolyrpo_pure5v_dis=0.0e-06
parameters dxl_ppolyrpo_pure5v_dis=0.0e-06
parameters r_rnwsti_dis=963.6 + (47.355) * a1_disres_nw
parameters rend_rnwsti_dis=250e-6 + (1.5026e-005) * a1_disres_nw
parameters r_rnwsti_pure5v_dis=1070 + (105.93) * a1_disres_nw
parameters rend_rnwsti_pure5v_dis=380e-6 + (4.0305e-005) * a1_disres_nw
parameters r_rnwod_dis=416 + (16.179) * a1_disres_nw
parameters rend_rnwod_dis=205e-6 + (8.879e-006) * a1_disres_nw
parameters r_rnwod_pure5v_dis=586 + (22.79) * a1_disres_nw
parameters rend_rnwod_pure5v_dis=250e-6 + (1.0828e-005) * a1_disres_nw
parameters ca_pofox=1.38e-17
parameters cf_polfox=4.16e-17
parameters cf_posfox=4.16e-17
 
include "cmn018_gp2a_5v_v1d4.scs" section=disres
endsection mc_disres
 
 
 
 
 
// *************************** Typical corner of resistor ***********************************

section tt_disres
include "cmn018_gp2a_5v_v1d4.scs" section=setup_disres
parameters par_res_dis=0
parameters r_rnod_dis=7.28
parameters r_rnodw_dis=7.28
parameters r_rpod_dis=7.49
parameters r_rpodw_dis=7.49
parameters r_rnpo1_dis=8.23
parameters r_rnpo1w_dis=8.23
parameters r_rppo1_dis=8.41
parameters r_rppo1w_dis=8.41
parameters r_rnodrpo_dis=82.9
parameters rend_rnodrpo_dis=0.00001586
parameters dxl_rnodrpo_dis=0u
parameters x_dxw_rnodrpo_dis=0u
parameters r_rpodrpo_dis=128.2
parameters rend_rpodrpo_dis=0.0000285
parameters dxl_rpodrpo_dis=0u
parameters x_dxw_rpodrpo_dis=0u
parameters r_rnpo1rpo_dis=322.5
parameters rend_rnpo1rpo_dis=0.000105
parameters dxl_rnpo1rpo_dis=0u
parameters x_dxw_rnpo1rpo_dis=0u
parameters r_rppo1rpo_dis=350.8
parameters rend_rppo1rpo_dis=0.000133
parameters dxl_rppo1rpo_dis=0u
parameters x_dxw_rppo1rpo_dis=0u
parameters r_rppolyhri_dis=1026.123930
parameters rend_rppolyhri_dis=1.203938e-04
parameters dxl_rppolyhri_dis=0e-6
parameters x_dxw_rppolyhri_dis=0e-6
parameters r_rppolyhri3k_dis=3110
parameters rend_rppolyhri3k_dis=0.0000695
parameters x_dxl_rppolyhri3k_dis=0u
parameters x_dxw_rppolyhri3k_dis=0u
parameters r_nodrpo_pure5v_dis=83.050
parameters rend_nodrpo_pure5v_dis=2.522e-05
parameters dxl_nodrpo_pure5v_dis=0.0e-06
parameters x_dxw_nodrpo_pure5v_dis=0
parameters r_podrpo_pure5v_dis=120.229
parameters rend_podrpo_pure5v_dis=4.1589e-05
parameters dxl_podrpo_pure5v_dis=0.0e-06
parameters x_dxw_podrpo_pure5v_dis=0
parameters r_npolyrpo_pure5v_dis=355.35
parameters rend_npolyrpo_pure5v_dis=9.561e-05
parameters dxl_npolyrpo_pure5v_dis=0.0e-06
parameters x_dxw_npolyrpo_pure5v_dis=0
parameters r_ppolyrpo_pure5v_dis=335
parameters rend_ppolyrpo_pure5v_dis=0.00017
parameters dxl_ppolyrpo_pure5v_dis=0.0e-06
parameters x_dxw_ppolyrpo_pure5v_dis=0
parameters r_rnwsti_dis=963.6
parameters rend_rnwsti_dis=250e-6
parameters r_rnwsti_pure5v_dis=1070
parameters rend_rnwsti_pure5v_dis=380e-6
parameters r_rnwod_dis=416
parameters rend_rnwod_dis=205e-6
parameters r_rnwod_pure5v_dis=586
parameters rend_rnwod_pure5v_dis=250e-6
parameters ca_pofox=1.38e-17
parameters cf_polfox=4.16e-17
parameters cf_posfox=4.16e-17
 
include "cmn018_gp2a_5v_v1d4.scs" section=disres
endsection tt_disres
 
 
 
// *************************** Slow corner of resistor ***********************************

section ss_disres
include "cmn018_gp2a_5v_v1d4.scs" section=setup_disres
parameters par_res_dis=0
parameters r_rnod_dis=7.28 * 1.3666
parameters r_rnodw_dis=7.28 * 1.3666
parameters r_rpod_dis=7.49 * 1.3867
parameters r_rpodw_dis=7.49 * 1.3867
parameters r_rnpo1_dis=8.23 * 1.2534
parameters r_rnpo1w_dis=8.23 * 1.2534
parameters r_rppo1_dis=8.41 * 1.3164
parameters r_rppo1w_dis=8.41 * 1.3164
parameters r_rnodrpo_dis=82.9 * 1.0684
parameters rend_rnodrpo_dis=1.586e-05 * 1.202
parameters dxl_rnodrpo_dis=0u - 0u
parameters x_dxw_rnodrpo_dis=1
parameters r_rpodrpo_dis=128.2 * 1.0696
parameters rend_rpodrpo_dis=2.850e-05 * 1.175
parameters dxl_rpodrpo_dis=0u - 0u
parameters x_dxw_rpodrpo_dis=1
parameters r_rnpo1rpo_dis=322.5 * 1.0698
parameters rend_rnpo1rpo_dis=1.050e-04 * 1.2105
parameters dxl_rnpo1rpo_dis=0u - 0u
parameters x_dxw_rnpo1rpo_dis=1
parameters r_rppo1rpo_dis=350.8 * 1.0712
parameters rend_rppo1rpo_dis=1.300e-04 * 1.1705
parameters dxl_rppo1rpo_dis=0u - 0u
parameters x_dxw_rppo1rpo_dis=1
parameters r_rppolyhri_dis=1026.123930 * 1.132
parameters rend_rppolyhri_dis=1.203938e-04 * 1.375
parameters dxl_rppolyhri_dis=0e-6 + 0e-6
parameters x_dxw_rppolyhri_dis=1
parameters r_rppolyhri3k_dis=3110 * 1.135
parameters rend_rppolyhri3k_dis=6.950e-05 * 1.4215
parameters x_dxl_rppolyhri3k_dis=1
parameters x_dxw_rppolyhri3k_dis=1
parameters r_nodrpo_pure5v_dis=83.050 * 1.07
parameters rend_nodrpo_pure5v_dis=2.522e-05 * 1.33
parameters dxl_nodrpo_pure5v_dis=0 + 0.0
parameters x_dxw_nodrpo_pure5v_dis=1
parameters r_podrpo_pure5v_dis=120.229 * 1.07
parameters rend_podrpo_pure5v_dis=4.1589e-05 * 1.095
parameters dxl_podrpo_pure5v_dis=0 + 0.0
parameters x_dxw_podrpo_pure5v_dis=1
parameters r_npolyrpo_pure5v_dis=355.35 * 1.137
parameters rend_npolyrpo_pure5v_dis=9.561e-05 * 1.15
parameters dxl_npolyrpo_pure5v_dis=0 + 0.0
parameters x_dxw_npolyrpo_pure5v_dis=1
parameters r_ppolyrpo_pure5v_dis=335 * 1.09
parameters rend_ppolyrpo_pure5v_dis=0.00017 * 1.185
parameters dxl_ppolyrpo_pure5v_dis=0 + 0.0
parameters x_dxw_ppolyrpo_pure5v_dis=1
parameters r_rnwsti_dis=963.6 * 1.139
parameters rend_rnwsti_dis=250e-6 * 1.17
parameters r_rnwsti_pure5v_dis=1070 * 1.28
parameters rend_rnwsti_pure5v_dis=380e-6 * 1.3
parameters r_rnwod_dis=416 * 1.11
parameters rend_rnwod_dis=205e-6 * 1.125
parameters r_rnwod_pure5v_dis=586 * 1.11
parameters rend_rnwod_pure5v_dis=250e-6 * 1.125
parameters ca_pofox=1.49e-17
parameters cf_polfox=4.25e-17
parameters cf_posfox=4.25e-17
 
include "cmn018_gp2a_5v_v1d4.scs" section=disres
endsection ss_disres
 
 
 
// *************************** Fast corner of resistor ***********************************

section ff_disres
include "cmn018_gp2a_5v_v1d4.scs" section=setup_disres
parameters par_res_dis=0
parameters r_rnod_dis=7.28 * 0.6334
parameters r_rnodw_dis=7.28 * 0.6334
parameters r_rpod_dis=7.49 * 0.6133
parameters r_rpodw_dis=7.49 * 0.6133
parameters r_rnpo1_dis=8.23 * 0.7463
parameters r_rnpo1w_dis=8.23 * 0.7463
parameters r_rppo1_dis=8.41 * 0.6836
parameters r_rppo1w_dis=8.41 * 0.6836
parameters r_rnodrpo_dis=82.9 * 0.9316
parameters rend_rnodrpo_dis=1.586e-05 * 0.798
parameters dxl_rnodrpo_dis=0u + 0.045u
parameters x_dxw_rnodrpo_dis=-1
parameters r_rpodrpo_dis=128.2 * 0.9304
parameters rend_rpodrpo_dis=2.850e-05 * 0.825
parameters dxl_rpodrpo_dis=0u + 0.0575u
parameters x_dxw_rpodrpo_dis=-1
parameters r_rnpo1rpo_dis=322.5 * 0.9302
parameters rend_rnpo1rpo_dis=1.050e-04 * 0.7895
parameters dxl_rnpo1rpo_dis=0u + 0.029u
parameters x_dxw_rnpo1rpo_dis=-1
parameters r_rppo1rpo_dis=350.8 * 0.9288
parameters rend_rppo1rpo_dis=1.300e-04 * 0.8295
parameters dxl_rppo1rpo_dis=0u + 0.0265u
parameters x_dxw_rppo1rpo_dis=-1
parameters r_rppolyhri_dis=1026.123930 * 0.872
parameters rend_rppolyhri_dis=1.203938e-04 * 0.55
parameters dxl_rppolyhri_dis=0e-6 + 0e-6
parameters x_dxw_rppolyhri_dis=-1
parameters r_rppolyhri3k_dis=3110 * 0.885
parameters rend_rppolyhri3k_dis=6.950e-05 * 0.5785
parameters x_dxl_rppolyhri3k_dis=-1
parameters x_dxw_rppolyhri3k_dis=-1
parameters r_nodrpo_pure5v_dis=83.050 * 0.94
parameters rend_nodrpo_pure5v_dis=2.522e-05 * 0.5
parameters dxl_nodrpo_pure5v_dis=0.0e-06 + 0.0e-06
parameters x_dxw_nodrpo_pure5v_dis=-1
parameters r_podrpo_pure5v_dis=120.229 * 0.935
parameters rend_podrpo_pure5v_dis=4.1589e-05 * 0.88
parameters dxl_podrpo_pure5v_dis=0.0e-06 + 0.0e-06
parameters x_dxw_podrpo_pure5v_dis=-1
parameters r_npolyrpo_pure5v_dis=355.35 * 0.87
parameters rend_npolyrpo_pure5v_dis=9.561e-05 * 0.83
parameters dxl_npolyrpo_pure5v_dis=0.0e-06 + 0.0e-06
parameters x_dxw_npolyrpo_pure5v_dis=-1
parameters r_ppolyrpo_pure5v_dis=335 * 0.925
parameters rend_ppolyrpo_pure5v_dis=0.00017 * 0.85
parameters dxl_ppolyrpo_pure5v_dis=0.0e-06 + 0.0e-06
parameters x_dxw_ppolyrpo_pure5v_dis=-1
parameters r_rnwsti_dis=963.6 * 0.861
parameters rend_rnwsti_dis=250e-6 * 0.83
parameters r_rnwsti_pure5v_dis=1070 * 0.72
parameters rend_rnwsti_pure5v_dis=380e-6 * 0.7
parameters r_rnwod_dis=416 * 0.89
parameters rend_rnwod_dis=205e-6 * 0.88
parameters r_rnwod_pure5v_dis=586 * 0.89
parameters rend_rnwod_pure5v_dis=250e-6 * 0.88
parameters ca_pofox=1.28e-17
parameters cf_polfox=4.08e-17
parameters cf_posfox=4.08e-17
 
include "cmn018_gp2a_5v_v1d4.scs" section=disres
endsection ff_disres
 
 
 
 

section disres
// ************************************
//        3T Resister model           *
// ************************************
 
subckt rnod_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01142 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnod_dis * (1 + factmis) / 4 dw=-0.0858u pvc2w=2.38e-013 
+ * (min(wr * factor * 1e6,10)) * (min(wr * factor * 1e6,10)) - 1.50e-13 * (min(wr 
+ * factor * 1e6,10)) + 7.45e-12 ptc1=3.35e-3 ptc2=4.31e-7 pvc1=4.19e-08 pvc2=pvc2w 
+ * (1.0 - 7.78e-03 * (pt - 25.0) + 5.23e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25) rmain=rsh / mf 
+ * lr * factor / (wr * factor - dw) * tfac 
r1 ( n2 nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx n1 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
d1 ( body n2 ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( body nm ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d3 ( body nn ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d4 ( body nx ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d5 ( body n1 ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rnod_m
 
 
// *************************** N+ OD w/i silicide 0.22um<W<2um ***********************************
subckt rnodw_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01142 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnodw_dis * (1 + factmis) / 4 dw=-0.0858u pvc2w=2.38e-013 
+ * (min(wr * factor * 1e6,10)) * (min(wr * factor * 1e6,10)) - 1.50e-13 * (min(wr 
+ * factor * 1e6,10)) + 7.45e-12 ptc1=3.35e-3 ptc2=4.31e-7 pvc1=4.19e-08 pvc2=pvc2w 
+ * (1.0 - 7.78e-03 * (pt - 25.0) + 5.23e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25) rmain=rsh / mf 
+ * lr * factor / (wr * factor - dw) * tfac 
r1 ( n2 nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx n1 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
d1 ( body n2 ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( body nm ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d3 ( body nn ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d4 ( body nx ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d5 ( body n1 ) ndio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rnodw_m
 
// *************************** N+ OD w/o silicide 2um<=W ***********************************
subckt rnodrpo_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.03420 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnodrpo_dis * (1 + factmis) rend0=rend_rnodrpo_dis * (1 + 
+ factmis) dw= - 4.470e-08 - 3.0103e-07 * (pow(0.7592,x_dxw_rnodrpo_dis) - 1) dl=0 
+ + dxl_rnodrpo_dis pvce1=0.0189 pvce2=3.92 pvce3=0.182 ptce1=7.691e-04 ptce2=-1.678e-06 
+ pvcp1=-0.299 pvcp2=-0.00000764 pvcp3=2.449 ptcp1=1.548e-03 ptcp2=5.250e-07 pt=temp 
+ tface=1.0 + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 
+ + ptcp1 * (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n2 ns ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r2 ( nm nn ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r3 ( nn nx ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r4 ( nx ne ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
rend2 ( ne n1 ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
d1 ( body ns ) ndio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * ((wr - dw / factor) + 2.0 * (lr - dl / factor) / 5.0)
d2 ( body nm ) ndio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d3 ( body nn ) ndio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d4 ( body nx ) ndio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d5 ( body ne ) ndio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * ((wr - dw / factor) + 2.0 * (lr - dl / factor) / 5.0)
ends rnodrpo_m
 
// *************************** P+ OD w/i silicide W>2um ***********************************
subckt rpod_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01604 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rpod_dis * (1 + factmis) / 4 dw=-0.087u pvc2w= - 9.03e-014 
+ * (min(wr * factor * 1e6,10)) * (min(wr * factor * 1e6,10)) + 4.08e-12 * (min(wr 
+ * factor * 1e6,10)) + 3.79e-12 ptc1=3.38e-3 ptc2=4.31e-7 pvc1=8.55e-09 pvc2=pvc2w 
+ * (1.0 - 5.43e-03 * (pt - 25.0) + 2.58e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25) rmain=rsh / mf 
+ * lr * factor / (wr * factor - dw) * tfac 
r1 ( n2 nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx n1 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
d1 ( n2 body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( nm body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d3 ( nn body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d4 ( nx body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d5 ( n1 body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rpod_m
 
// *************************** P+ OD w/i silicide 0.22um<W<2um ***********************************
subckt rpodw_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01604 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rpodw_dis * (1 + factmis) / 4 dw=-0.087u pvc2w= - 9.03e-014 
+ * (min(wr * factor * 1e6,10)) * (min(wr * factor * 1e6,10)) + 4.08e-12 * (min(wr 
+ * factor * 1e6,10)) + 3.79e-12 ptc1=3.38e-3 ptc2=4.31e-7 pvc1=8.55e-09 pvc2=pvc2w 
+ * (1.0 - 5.43e-03 * (pt - 25.0) + 2.58e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25) rmain=rsh / mf 
+ * lr * factor / (wr * factor - dw) * tfac 
r1 ( n2 nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx n1 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
d1 ( n2 body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( nm body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d3 ( nn body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d4 ( nx body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr / 
+ 5.0
d5 ( n1 body ) pdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rpodw_m
 
// **********************************     P+OD w/o silicide resistor     ***********************************
subckt rpodrpo_m ( n2 n1 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01008 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rpodrpo_dis * (1 + factmis) rend0=rend_rpodrpo_dis * (1 + 
+ factmis) dw= - 2.050e-08 - 3.8619e-07 * (pow(0.80762,x_dxw_rpodrpo_dis) - 1) dl=0 
+ + dxl_rpodrpo_dis pvce1=0.3 pvce2=-3.6 pvce3=0.01 ptce1=-3.050e-04 ptce2=1.100e-06 
+ pvcp1=-0.6968 pvcp2=-0.000001807 pvcp3=2.1 ptcp1=1.423e-03 ptcp2=8.632e-07 pt=temp 
+ tface=1.0 + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 
+ + ptcp1 * (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n2 ns ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r2 ( nm nn ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r3 ( nn nx ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r4 ( nx ne ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
rend2 ( ne n1 ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
d1 ( ns body ) pdio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * ((wr - dw / factor) + 2.0 * (lr - dl / factor) / 5.0)
d2 ( nm body ) pdio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d3 ( nn body ) pdio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d4 ( nx body ) pdio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * (2.0 * (lr - dl / factor) / 5.0)
d5 ( ne body ) pdio area=mf * ((wr - dw / factor) * (lr - dl / factor) / 5.0) pj=mf 
+ * ((wr - dw / factor) + 2.0 * (lr - dl / factor) / 5.0)
ends rpodrpo_m
 
// *************************** N+Poly w/i silicide W>2um ***********************************
subckt rnpo1_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.0101 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnpo1_dis * (1 + factmis) / 4 dw=-0.031u pvc2w= - 1.52e-012 
+ * (min(wr * factor * 1e6,10)) * (min(wr * factor * 1e6,10)) + 2.17e-11 * (min(wr 
+ * factor * 1e6,10)) + 2.34e-11 ptc1=3.1e-3 ptc2=2.66e-7 pvc1=-4.32e-9 pvc2=pvc2w 
+ * (1.0 - 7.07e-03 * (pt - 25.0) + 3.02e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf 
+ * lr * factor / (wr * factor - dw) * tfac ca=ca_pofox cf=cf_polfox 
r1 ( n2 nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx n1 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
c1 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rnpo1_dis
 
// *************************** N+Poly w/i silicide 0.18um<W<2um ***********************************
subckt rnpo1w_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.0101 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnpo1w_dis * (1 + factmis) / 4 dw=-0.031u pvc2w= - 1.52e-012 
+ * (min(wr * factor * 1e6,10)) * (min(wr * factor * 1e6,10)) + 2.17e-11 * (min(wr 
+ * factor * 1e6,10)) + 2.34e-11 ptc1=3.1e-3 ptc2=2.66e-7 pvc1=-4.32e-9 pvc2=pvc2w 
+ * (1.0 - 7.07e-03 * (pt - 25.0) + 3.02e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf 
+ * lr * factor / (wr * factor - dw) * tfac ca=ca_pofox cf=cf_posfox 
r1 ( n2 nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx n1 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
c1 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rnpo1w_dis
 
// *************************** P+Poly w/i silicide W>2um ***********************************
subckt rppo1_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01320 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rppo1_dis * (1 + factmis) / 4 dw=-0.013u pvc2w= - 1.58e-012 
+ * (min(wr * factor * 1e6,10)) * (min(wr * factor * 1e6,10)) + 2.22e-11 * (min(wr 
+ * factor * 1e6,10)) + 2.02e-11 ptc1=2.98e-3 ptc2=5.01e-7 pvc1=-4.2e-09 pvc2=pvc2w 
+ * (1.0 - 5.83e-03 * (pt - 25.0) + 2.27e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf 
+ * lr * factor / (wr * factor - dw) * tfac ca=ca_pofox cf=cf_polfox 
r1 ( n2 nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx n1 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
c1 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rppo1_dis
 
// *************************** P+Poly w/i silicide 0.18um<W<2um ***********************************
subckt rppo1w_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01320 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rppo1w_dis * (1 + factmis) / 4 dw=-0.013u pvc2w= - 1.58e-012 
+ * (min(wr * factor * 1e6,10)) * (min(wr * factor * 1e6,10)) + 2.22e-11 * (min(wr 
+ * factor * 1e6,10)) + 2.02e-11 ptc1=2.98e-3 ptc2=5.01e-7 pvc1=-4.2e-09 pvc2=pvc2w 
+ * (1.0 - 5.83e-03 * (pt - 25.0) + 2.27e-05 * (pt - 25.0) * (pt - 25.0)) pt=temp 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf 
+ * lr * factor / (wr * factor - dw) * tfac ca=ca_pofox cf=cf_posfox 
r1 ( n2 nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx n1 ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(n2,n1)) / lr / factor) 
+ + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
c1 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rppo1w_dis
 
// *************************** N+Poly w/o silicide 2um<W ***********************************
subckt rnpo1rpo_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.02506 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnpo1rpo_dis * (1 + factmis) rend0=rend_rnpo1rpo_dis * (1 
+ + factmis) dl=0.000e+00 + dxl_rnpo1rpo_dis dw=8.700e-08 - 2.7819e-07 * (pow(0.7649,x_dxw_rnpo1rpo_dis) 
+ - 1) pt=temp pvce1=0.5 pvce2=2.5 pvce3=1.432 ptce1=-1.784e-03 ptce2=-3.950e-07 
+ pvcp1=-0.117 pvcp2=0.0000047 pvcp3=-1.88 ptcp1=-1.456e-03 ptcp2=2.679e-06 tface=1.0 
+ + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * 
+ (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) ca=ca_pofox cf=cf_polfox 
rend1 ( n2 ns ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r2 ( nm nn ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r3 ( nn nx ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r4 ( nx ne ) resistor r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(ns,ne) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
rend2 ( ne n1 ) resistor r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
c1 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rnpo1rpo_dis
 
// *************************** P+Poly w/o silicide 2um<W ***********************************
subckt rppo1rpo_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01046 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rppo1rpo_dis / 4 * (1 + factmis) rendsh=rend_rppo1rpo_dis 
+ * (1 + factmis) * 1e6 dl=0.000e+00 + dxl_rppo1rpo_dis dw_etch=0u - 2.5041e-07 
+ * (pow(0.7488,x_dxw_rppo1rpo_dis) - 1) dw_emp=3.400e-08 dw_empend=0 dw=(dw_etch 
+ + dw_emp) * 1e6 dwend=0 jc1_0=0.103428536300757 jc1_w=0.0237600720950873 jc1_n=0.0005981670378054 
+ jc1end_0=1.80682127611015 jc1end_w=0.68716151233078 tc1_0=-0.000252990022695571 
+ tc1_w=6.3169024328277e-06 tc2_0=6.75735736450397e-07 tc2_w=-6.97977253756941e-10 
+ tc1end_0=-0.00164627865883391 tc1end_w=9.75942711452446e-06 tc2end_0=4.21852469059498e-07 
+ tc2end_w=-2.33978426054113e-09 jct_0=-0.00509298249983379 jct_w=-0.00015629755371274 
+ jctend_0=0.000981261188626716 jctend_w=0.000325620892259473 delta_t=temp - 25 
+ lum=lr * factor * 1e6 wum=wr * factor * 1e6 nsqr=lr/wr tc1=tc1_0 + tc1_w * min(wum,10) 
+ tc2=tc2_0 + tc2_w * min(wum,10) tc1end=tc1end_0 + tc1end_w * min(wum,10) tc2end=tc2end_0 
+ + tc2end_w * min(wum,10) jct=jct_0 + jct_w * min(wum,10) jctend=jctend_0 + jctend_w 
+ * min(wum,10) jc1=max(0,(jc1_0 + jc1_w * min(wum,10) + jc1_n * min(nsqr,73)) * 
+ (1 + jct * delta_t) / (lum - dl) / (lum - dl)) jc1_r=jc1 * 16 jc1end=max(0,(jc1end_0 
+ + jc1end_w * min(wum,10)) * (1 + jctend * delta_t)) jc1end_r=jc1end * 4 tfac=1 
+ + tc1 * delta_t + tc2 * delta_t * delta_t tfacend=1 + tc1end * delta_t + tc2end 
+ * delta_t * delta_t rendo=rendsh / mf / (wum - dwend) * tfacend ro=rsh / mf * 
+ (lum - dl) / (wum - dw) * tfac ca=ca_pofox cf=cf_polfox 
rend1 ( n2 ns ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(n2,ns) 
+ * v(n2,ns))),rendo * 1.5),rendo / 2)
r1 ( ns nm ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(ns,nm) * v(ns,nm))),ro 
+ * 1.5),ro / 2)
r2 ( nm nn ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nm,nn) * v(nm,nn))),ro 
+ * 1.5),ro / 2)
r3 ( nn nx ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nn,nx) * v(nn,nx))),ro 
+ * 1.5),ro / 2)
r4 ( nx ne ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nx,ne) * v(nx,ne))),ro 
+ * 1.5),ro / 2)
rend2 ( ne n1 ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(ne,n1) 
+ * v(ne,n1))),rendo * 1.5),rendo / 2)
c1 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rppo1rpo_dis
 
// *************************** P- Poly w/o silicide 2um<W ***********************************
subckt rppolyhri_dis ( n1 n2 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.00964 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rppolyhri_dis / 4 * (1 + factmis) rendsh=rend_rppolyhri_dis 
+ * 1e6 * (1 + factmis) dw_etch=0u - 3.9286e-08 * (pow(0.44,x_dxw_rppolyhri_dis) 
+ - 1) dw_emp=6.5410714883522e-08 dw_empend=7.410714883522e-10 dl_etch=0 dw=(dw_etch 
+ + dw_emp) * 1e6 dwend=(dw_etch + dw_empend) * 1e6 dl=(dl_etch + dxl_rppolyhri_dis) 
+ * 1e6 jc1_0=0.1474037106889946 jc1_w=0.0400847859662231 jc1_n=0.000964257603206478 
+ jc1end_0=5.878327431421787 jc1end_w=2.65607312261631 tc1_0=-0.00103412157111652 
+ tc1_w=1.10638460995948e-05 tc2_0=2.50172779429575e-06 tc2_w=-7.29824957952402e-08 
+ tc1end_0=-0.000530197650596438 tc1end_w=-0.000148415177260185 tc2end_0=-1.40888462983242e-06 
+ tc2end_w=8.23396549335135e-07 jct_0=-0.00341305960400095 jct_w=5.19508920284451e-05 
+ jctend_0=-0.00469373756335246 jctend_w=0.00101066163029796 delta_t=temp - 25 
+ lum=lr * factor * 1e6 wum=wr * factor * 1e6 nsqr=lr/wr tc1=tc1_0 + tc1_w * min(wum,10) 
+ tc2=tc2_0 + tc2_w * min(wum,10) tc1end=tc1end_0 + tc1end_w * min(wum,10) tc2end=tc2end_0 
+ + tc2end_w * min(wum,10) jct=jct_0 + jct_w * min(wum,10) jctend=jctend_0 + jctend_w 
+ * min(wum,10) jc1=(jc1_0 + jc1_w * min(wum,10) + jc1_n * min(nsqr,20)) * (1 + 
+ jct * delta_t) / (lum - dl) / (lum - dl) jc1_r=jc1 * 16 jc1end=max(0,(jc1end_0 
+ + jc1end_w * min(wum,10)) * (1 + jctend * delta_t)) jc1end_r=jc1end * 4 tfac=1 
+ + tc1 * delta_t + tc2 * delta_t * delta_t tfacend=1 + tc1end * delta_t + tc2end 
+ * delta_t * delta_t rendo=rendsh / mf / (wum - dwend) * tfacend ro=rsh / mf * 
+ (lum - dl) / (wum - dw) * tfac ca=ca_pofox cf=cf_polfox 
rend1 ( n2 ns ) resistor r=max(min(rendo / 2 * (3 - 1 / (1 + jc1end_r * v(n2,ns) 
+ * v(n2,ns))),rendo * 1.5),rendo / 2)
r1 ( ns nm ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(ns,nm) * v(ns,nm))),ro 
+ * 1.5),ro / 2)
r2 ( nm nn ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nm,nn) * v(nm,nn))),ro 
+ * 1.5),ro / 2)
r3 ( nn nx ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nn,nx) * v(nn,nx))),ro 
+ * 1.5),ro / 2)
r4 ( nx ne ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nx,ne) * v(nx,ne))),ro 
+ * 1.5),ro / 2)
rend2 ( ne n1 ) resistor r=max(min(rendo / 2 * (3 - 1 / (1 + jc1end_r * v(ne,n1) 
+ * v(ne,n1))),rendo * 1.5),rendo / 2)
c1 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rppolyhri_dis
 
// **********************************     P-POLY w/o silicide resistor     ***********************************
subckt rppolyhri3k_dis ( n1 n2 body ) 
parameters lr=1u wr=1u mf=1 factor=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.0180 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rppolyhri3k_dis / 4 * (1 + factmis) rendsh=rend_rppolyhri3k_dis 
+ / 2 * 1e6 * (1 + factmis) dw=7.3e-02 + ( - 3.5315e-08 * (pow(0.30625,x_dxw_rppolyhri3k_dis) 
+ - 1)) * 1e6 dwend=0 dl=1.50e-01 + ( - 1.8e-7 * (pow(1.1111,x_dxl_rppolyhri3k_dis) 
+ - 1)) * 1e6 jc1_0=0.0284541776598384 jc1_w=0.0552178046415412 * 1.2 jc1_n=0.000714344378379032 
+ * 2.5 jc1end_0=0 jc1end_w=0 tc1_0=-0.002016610001954663 tc1_w=1.80006103761493e-05 
+ tc2_0=5.06026391020496e-06 tc2_w=-1.21111777945279e-07 tc1end_0=0 tc1end_w=0 tc2end_0=0 
+ tc2end_w=0 jct_0=-0.00386214585793815 jct_w=0.00019185053193552 jctend_0=0 jctend_w=0 
+ delta_t=temp - 25 lum=lr * factor * 1e6 wum=wr * factor * 1e6 nsqr=lr/wr tc1=tc1_0 
+ + tc1_w * wum tc2=tc2_0 + tc2_w * wum tc1end=tc1end_0 + tc1end_w * wum tc2end=tc2end_0 
+ + tc2end_w * wum jct=jct_0 + jct_w * wum jctend=jctend_0 + jctend_w * wum jc1=max(0,(jc1_0 
+ + jc1_w * wum + jc1_n * nsqr) * (1 + jct * delta_t) / (lum - dl) / (lum - dl)) 
+ jc1_r=jc1 * 16 jc1end_r=jc1end * 4 jc1end=max(0,(jc1end_0 + jc1end_w * wum) * 
+ (1 + jctend * delta_t)) tfac=1 + tc1 * delta_t + tc2 * delta_t * delta_t tfacend=1 
+ + tc1end * delta_t + tc2end * delta_t * delta_t rendo=rendsh / mf / (wum - dwend) 
+ * tfacend ro=rsh / mf * (lum - dl) / (wum - dw) * tfac ca=ca_pofox cf=cf_polfox 
rend1 ( n2 ns ) resistor r=max(min(rendo / 2 * (3 - 1 / (1 + jc1end_r * v(n2,ns) 
+ * v(n2,ns))),rendo * 1.5),rendo / 2)
r1 ( ns nm ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(ns,nm) * v(ns,nm))),ro 
+ * 1.5),ro / 2)
r2 ( nm nn ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nm,nn) * v(nm,nn))),ro 
+ * 1.5),ro / 2)
r3 ( nn nx ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nn,nx) * v(nn,nx))),ro 
+ * 1.5),ro / 2)
r4 ( nx ne ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nx,ne) * v(nx,ne))),ro 
+ * 1.5),ro / 2)
rend2 ( ne n1 ) resistor r=max(min(rendo / 2 * (3 - 1 / (1 + jc1end_r * v(ne,n1) 
+ * v(ne,n1))),rendo * 1.5),rendo / 2)
c1 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rppolyhri3k_dis
 
// *************************** N+ OD w/o silicide 2um<=W (pure5V)***********************************
subckt rnodrpo_pure5v_m ( n1 n2 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.0345 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_nodrpo_pure5v_dis / 4 * (1 + factmis) rendsh=rend_nodrpo_pure5v_dis 
+ * 1e6 * (1 + factmis) dw_etch=0u - 2.3333e-07 * (pow(0.7,x_dxw_nodrpo_pure5v_dis) 
+ - 1) dw_emp=-7.04e-08 dw_empend=-1.29859012784265e-07 dl_etch=0 dw=(dw_etch + 
+ dw_emp) * 1e6 dwend=(dw_etch + dw_empend) * 1e6 dl=(dl_etch + dxl_nodrpo_pure5v_dis) 
+ * 1e6 jc1_0=0.26049641179018 jc1_w=0.338753336333001 jc1_n=0.0115470183520801 
+ jc1end_0=0.482123799537825 jc1end_w=0.0465075945675371 tc1_0=0.00163760188660371 
+ tc1_w=4.869908308429e-06 tc2_0=-5.1547590573148e-07 tc2_w=-1.66380122167674e-08 
+ tc1end_0=0.000678492619996571 tc1end_w=0.00013178484793306 tc2end_0=-1.88756918539424e-07 
+ tc2end_w=-7.42454642097019e-07 jct_0=-0.000221973003336103 jct_w=0.000308757232255487 
+ jctend_0=-0.0523812972984853 jctend_w=0.076695898710281 delta_t=temp - 25 lum=lr 
+ * factor * 1e6 wum=wr * factor * 1e6 nsqr=lr/wr tc1=tc1_0 + tc1_w * min(wum,10) 
+ tc2=tc2_0 + tc2_w * min(wum,10) tc1end=tc1end_0 + tc1end_w * min(wum,10) tc2end=tc2end_0 
+ + tc2end_w * min(wum,10) jct=jct_0 + jct_w * min(wum,10) jctend=jctend_0 + jctend_w 
+ * min(wum,10) jc1=max(0,(jc1_0 + jc1_w * min(wum,10) + jc1_n * min(nsqr,73)) * 
+ (1 + jct * delta_t) / (lum - dl) / (lum - dl)) jc1_r=jc1 * 16 jc1end=max(0,(jc1end_0 
+ + jc1end_w * min(wum,10)) * (1 + jctend * delta_t)) jc1end_r=jc1end * 4 tfac=1 
+ + tc1 * delta_t + tc2 * delta_t * delta_t tfacend=1 + tc1end * delta_t + tc2end 
+ * delta_t * delta_t rendo=rendsh / mf / (wum - dwend) * tfacend ro=rsh / mf * 
+ (lum - dl) / (wum - dw) * tfac 
rend1 ( n2 ns ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(n2,ns) 
+ * v(n2,ns))),rendo * 1.5),rendo / 2)
r1 ( ns nm ) resistor r=max(min(ro / 2 * (3 - 1 / (1 + jc1_r * v(ns,nm) * v(ns,nm))),ro 
+ * 1.5),ro / 2)
r2 ( nm nn ) resistor r=max(min(ro / 2 * (3 - 1 / (1 + jc1_r * v(nm,nn) * v(nm,nn))),ro 
+ * 1.5),ro / 2)
r3 ( nn nx ) resistor r=max(min(ro / 2 * (3 - 1 / (1 + jc1_r * v(nn,nx) * v(nn,nx))),ro 
+ * 1.5),ro / 2)
r4 ( nx ne ) resistor r=max(min(ro / 2 * (3 - 1 / (1 + jc1_r * v(nx,ne) * v(nx,ne))),ro 
+ * 1.5),ro / 2)
rend2 ( ne n1 ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(ne,n1) 
+ * v(ne,n1))),rendo * 1.5),rendo / 2)
d1 ( body ns ) ndio area=mf * ((wr - dw / factor * 1e-6) * (lr - dl / factor * 1e-6) 
+ / 5.0) pj=mf * ((wr - dw / factor * 1e-6) + 2.0 * (lr - dl / factor * 1e-6) / 
+ 5.0)
d2 ( body nm ) ndio area=mf * ((wr - dw / factor * 1e-6) * (lr - dl / factor * 1e-6) 
+ / 5.0) pj=mf * (2.0 * (lr - dl / factor * 1e-6) / 5.0)
d3 ( body nn ) ndio area=mf * ((wr - dw / factor * 1e-6) * (lr - dl / factor * 1e-6) 
+ / 5.0) pj=mf * (2.0 * (lr - dl / factor * 1e-6) / 5.0)
d4 ( body nx ) ndio area=mf * ((wr - dw / factor * 1e-6) * (lr - dl / factor * 1e-6) 
+ / 5.0) pj=mf * (2.0 * (lr - dl / factor * 1e-6) / 5.0)
d5 ( body ne ) ndio area=mf * ((wr - dw / factor * 1e-6) * (lr - dl / factor * 1e-6) 
+ / 5.0) pj=mf * ((wr - dw / factor * 1e-6) + 2.0 * (lr - dl / factor * 1e-6) / 
+ 5.0)
ends rnodrpo_pure5v_m
 
// *************************** P+ OD w/o silicide 2um<=W (pure5V)***********************************
subckt rpodrpo_pure5v_m ( n1 n2 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.009907 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_podrpo_pure5v_dis * (1 + factmis) / 4 rendsh=rend_podrpo_pure5v_dis 
+ * 1e6 * (1 + factmis) dw_etch=0u - 1.7727e-07 * (pow(0.5769,x_dxw_podrpo_pure5v_dis) 
+ - 1) dw_emp=-4.00e-08 dw_empend=-8.27061147481514e-08 dl_etch=0 dw=(dw_etch + 
+ dw_emp) * 1e6 dwend=(dw_etch + dw_empend) * 1e6 dl=(dl_etch + dxl_podrpo_pure5v_dis) 
+ * 1e6 jc1_0=0.09618866202628 jc1_w=0.226049398240571 jc1_n=0.00861902964341637 
+ jc1end_0=-2.96409728163819 jc1end_w=2.72971278363163 tc1_0=0.00144731708903961 
+ tc1_w=1.57298124939104e-05 tc2_0=-2.06130245947975e-07 tc2_w=-1.15247737940013e-08 
+ tc1end_0=-0.000119488998923866 tc1end_w=1.45662867931858e-05 tc2end_0=-5.42849184541314e-07 
+ tc2end_w=1.94384271799479e-07 jct_0=0.00151710515394783 jct_w=2.68954319339542e-05 
+ jctend_0=0.00159368183931327 jctend_w=0.00577596003187178 delta_t=temp - 25 
+ lum=lr * factor * 1e6 wum=wr * factor * 1e6 nsqr=lr/wr tc1=tc1_0 + tc1_w * min(wum,10) 
+ tc2=tc2_0 + tc2_w * min(wum,10) tc1end=tc1end_0 + tc1end_w * min(wum,10) tc2end=tc2end_0 
+ + tc2end_w * min(wum,10) jct=jct_0 + jct_w * min(wum,10) jctend=jctend_0 + jctend_w 
+ * min(wum,10) jc1=max(0,(jc1_0 + jc1_w * min(wum,10) + jc1_n * min(nsqr,73)) * 
+ (1 + jct * delta_t) / (lum - dl) / (lum - dl)) jc1_r=jc1 * 16 jc1end=max(0,(jc1end_0 
+ + jc1end_w * min(wum,10)) * (1 + jctend * delta_t)) jc1end_r=jc1end * 4 tfac=1 
+ + tc1 * delta_t + tc2 * delta_t * delta_t tfacend=1 + tc1end * delta_t + tc2end 
+ * delta_t * delta_t rendo=rendsh / mf / (wum - dwend) * tfacend ro=rsh / mf * 
+ (lum - dl) / (wum - dw) * tfac 
rend1 ( n2 ns ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(n2,ns) 
+ * v(n2,ns))),rendo * 1.5),rendo / 2)
r1 ( ns nm ) resistor r=max(min(ro / 2 * (3 - 1 / (1 + jc1_r * v(ns,nm) * v(ns,nm))),ro 
+ * 1.5),ro / 2)
r2 ( nm nn ) resistor r=max(min(ro / 2 * (3 - 1 / (1 + jc1_r * v(nm,nn) * v(nm,nn))),ro 
+ * 1.5),ro / 2)
r3 ( nn nx ) resistor r=max(min(ro / 2 * (3 - 1 / (1 + jc1_r * v(nn,nx) * v(nn,nx))),ro 
+ * 1.5),ro / 2)
r4 ( nx ne ) resistor r=max(min(ro / 2 * (3 - 1 / (1 + jc1_r * v(nx,ne) * v(nx,ne))),ro 
+ * 1.5),ro / 2)
rend2 ( ne n1 ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(ne,n1) 
+ * v(ne,n1))),rendo * 1.5),rendo / 2)
d1 ( ns body ) pdio area=mf * ((wr - dw / factor * 1e-6) * (lr - dl / factor * 1e-6) 
+ / 5.0) pj=mf * ((wr - dw / factor * 1e-6) + 2.0 * (lr - dl / factor * 1e-6) / 
+ 5.0)
d2 ( nm body ) pdio area=mf * ((wr - dw / factor * 1e-6) * (lr - dl / factor * 1e-6) 
+ / 5.0) pj=mf * (2.0 * (lr - dl / factor * 1e-6) / 5.0)
d3 ( nn body ) pdio area=mf * ((wr - dw / factor * 1e-6) * (lr - dl / factor * 1e-6) 
+ / 5.0) pj=mf * (2.0 * (lr - dl / factor * 1e-6) / 5.0)
d4 ( nx body ) pdio area=mf * ((wr - dw / factor * 1e-6) * (lr - dl / factor * 1e-6) 
+ / 5.0) pj=mf * (2.0 * (lr - dl / factor * 1e-6) / 5.0)
d5 ( ne body ) pdio area=mf * ((wr - dw / factor * 1e-6) * (lr - dl / factor * 1e-6) 
+ / 5.0) pj=mf * ((wr - dw / factor * 1e-6) + 2.0 * (lr - dl / factor * 1e-6) / 
+ 5.0)
ends rpodrpo_pure5v_m
 
// *************************** N+ POLY w/o silicide 2um<=W (pure5V)***********************************
subckt rnpo1rpo_pure5v_dis ( n1 n2 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.0302 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_npolyrpo_pure5v_dis * (1 + factmis) / 4 rendsh=rend_npolyrpo_pure5v_dis 
+ * 1e6 * (1 + factmis) dw_etch=0u - 8.8421e-08 * (pow(0.525,x_dxw_npolyrpo_pure5v_dis) 
+ - 1) dw_emp=8.84e-08 dw_empend=6.24351809003062e-08 dl_etch=0 dw=(dw_etch + dw_emp) 
+ * 1e6 dwend=(dw_etch + dw_empend) * 1e6 dl=(dl_etch + dxl_npolyrpo_pure5v_dis) 
+ * 1e6 jc1_0=0.593574049300358 jc1_w=0.208476151328853 jc1_n=0.009156387660113 
+ jc1end_0=-0.884382207504105 jc1end_w=1.74501073484064 tc1_0=-0.0016401156446971 
+ tc1_w=1.1650783389784e-06 tc2_0=4.26975595787514e-06 tc2_w=1.23630864199603e-08 
+ tc1end_0=-0.00224927008416115 tc1end_w=0.000463561787547606 tc2end_0=3.1723812326026e-06 
+ tc2end_w=-1.00922530619054e-08 jct_0=-0.00252818279600855 jct_w=-1.15641997879775e-06 
+ jctend_0=0.000762325032321053 jctend_w=-0.00297638541249764 delta_t=temp - 25 
+ lum=lr * factor * 1e6 wum=wr * factor * 1e6 nsqr=lr/wr tc1=tc1_0 + tc1_w * min(wum,10) 
+ tc2=tc2_0 + tc2_w * min(wum,10) tc1end=tc1end_0 + tc1end_w * min(wum,10) tc2end=tc2end_0 
+ + tc2end_w * min(wum,10) jct=jct_0 + jct_w * min(wum,10) jctend=jctend_0 + jctend_w 
+ * min(wum,10) jc1=max(0,(jc1_0 + jc1_w * min(wum,10) + jc1_n * min(nsqr,73)) * 
+ (1 + jct * delta_t) / (lum - dl) / (lum - dl)) jc1_r=jc1 * 16 jc1end=max(0,(jc1end_0 
+ + jc1end_w * min(wum,10)) * (1 + jctend * delta_t)) jc1end_r=jc1end * 4 tfac=1 
+ + tc1 * delta_t + tc2 * delta_t * delta_t tfacend=1 + tc1end * delta_t + tc2end 
+ * delta_t * delta_t rendo=rendsh / mf / (wum - dwend) * tfacend ro=rsh / mf * 
+ (lum - dl) / (wum - dw) * tfac ca=ca_pofox cf=cf_polfox 
rend1 ( n2 ns ) resistor r=max(min(rendo / 2 * (3 - 1 / (1 + jc1end_r * v(n2,ns) 
+ * v(n2,ns))),rendo * 1.5),rendo / 2)
r1 ( ns nm ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(ns,nm) * v(ns,nm))),ro 
+ * 1.5),ro / 2)
r2 ( nm nn ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nm,nn) * v(nm,nn))),ro 
+ * 1.5),ro / 2)
r3 ( nn nx ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nn,nx) * v(nn,nx))),ro 
+ * 1.5),ro / 2)
r4 ( nx ne ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nx,ne) * v(nx,ne))),ro 
+ * 1.5),ro / 2)
rend2 ( ne n1 ) resistor r=max(min(rendo / 2 * (3 - 1 / (1 + jc1end_r * v(ne,n1) 
+ * v(ne,n1))),rendo * 1.5),rendo / 2)
c1 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rnpo1rpo_pure5v_dis
 
// *************************** P+ POLY w/o silicide 2um<=W (pure5V)***********************************
subckt rppo1rpo_pure5v_dis ( n1 n2 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.01099 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_ppolyrpo_pure5v_dis / 4 * (1 + factmis) rendsh=rend_ppolyrpo_pure5v_dis 
+ * 1e6 * (1 + factmis) dw_etch=0u - 7.7209e-08 * (pow(0.4819,x_dxw_ppolyrpo_pure5v_dis) 
+ - 1) dw_emp=4.06e-08 dw_empend=-1.4e-7 dl_etch=0 dw=(dw_etch + dw_emp) * 1e6 dwend=(dw_etch 
+ + dw_empend) * 1e6 dl=(dl_etch + dxl_ppolyrpo_pure5v_dis) * 1e6 jc1_0=0.0985942031265099 
+ jc1_w=0.0184775076507981 jc1_n=0.00097581646698633 jc1end_0=-0.336669969160045 
+ jc1end_w=0.92324003118435 tc1_0=-0.000226586518387305 tc1_w=5.17097297941423e-06 
+ tc2_0=1.02672749831316e-06 tc2_w=-8.68683719247075e-09 tc1end_0=-0.00174146670729387 
+ tc1end_w=3.78726466980252e-05 tc2end_0=2.07404932553801e-06 tc2end_w=-1.81953330651118e-07 
+ jct_0=-0.0065275554346074 jct_w=-0.0000966075915608463 jctend_0=0.00103744395916669 
+ jctend_w=0.00095892093794262 delta_t=temp - 25 lum=lr * factor * 1e6 wum=wr 
+ * factor * 1e6 nsqr=lr/wr tc1=tc1_0 + tc1_w * min(wum,10) tc2=tc2_0 + tc2_w * 
+ min(wum,10) tc1end=tc1end_0 + tc1end_w * min(wum,10) tc2end=tc2end_0 + tc2end_w 
+ * min(wum,10) jct=jct_0 + jct_w * min(wum,10) jctend=jctend_0 + jctend_w * min(wum,10) 
+ jc1=(jc1_0 + jc1_w * min(wum,10) + jc1_n * min(nsqr,73)) * (1 + jct * delta_t) 
+ / (lum - dl) / (lum - dl) jc1_r=jc1 * 16 jc1end=(jc1end_0 + jc1end_w * min(wum,10)) 
+ * (1 + jctend * delta_t) jc1end_r=jc1end * 4 tfac=1 + tc1 * delta_t + tc2 * delta_t 
+ * delta_t tfacend=1 + tc1end * delta_t + tc2end * delta_t * delta_t rendo=rendsh 
+ / mf / (wum - dwend) * tfacend ro=rsh / mf * (lum - dl) / (wum - dw) * tfac ca=ca_pofox 
+ cf=cf_polfox 
rend1 ( n2 ns ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(n2,ns) 
+ * v(n2,ns))),rendo * 1.5),rendo / 2)
r1 ( ns nm ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(ns,nm) * v(ns,nm))),ro 
+ * 1.5),ro / 2)
r2 ( nm nn ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nm,nn) * v(nm,nn))),ro 
+ * 1.5),ro / 2)
r3 ( nn nx ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nn,nx) * v(nn,nx))),ro 
+ * 1.5),ro / 2)
r4 ( nx ne ) resistor r=max(min(ro / 2 * (1 + 1 / (1 + jc1_r * v(nx,ne) * v(nx,ne))),ro 
+ * 1.5),ro / 2)
rend2 ( ne n1 ) resistor r=max(min(rendo / 2 * (1 + 1 / (1 + jc1end_r * v(ne,n1) 
+ * v(ne,n1))),rendo * 1.5),rendo / 2)
c1 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rppo1rpo_pure5v_dis
 
// **********************************     N-well under STI resistor     ***********************************
subckt rnwsti_m ( n1 n2 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.00385 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnwsti_dis * (1 + factmis) / 4 dw=0.285e-6 pt=temp pvc1=4 
+ * ((3.369e-08 / (max(wr * factor * 1e6,1.8)) + 8.881e-10) * (min(lr * factor * 
+ 1e6,100)) + ( - 1.492e-07 / (max(wr * factor * 1e6,1.8)) + 1.643e-07)) pvc2=0 
+ ptc1=3.006e-03 ptc2=7.0932e-06 tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) 
+ * (pt - 25.0) rmain=rsh / mf * lr * factor / (wr * factor - dw) * tfac rend=rend_rnwsti_dis 
+ * (1 + factmis) 
rn1 ( n1 ns ) resistor r=rend / mf / (wr * factor)
r1 ( ns nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(ns,nm)) / lr / factor) 
+ + pvc2 * (v(ns,nm) / lr / factor) * (v(ns,nm) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nm,nn)) / lr / factor) 
+ + pvc2 * (v(nm,nn) / lr / factor) * (v(nm,nn) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nn,nx)) / lr / factor) 
+ + pvc2 * (v(nn,nx) / lr / factor) * (v(nn,nx) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx ne ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nx,ne)) / lr / factor) 
+ + pvc2 * (v(nx,ne) / lr / factor) * (v(nx,ne) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
rn2 ( ne n2 ) resistor r=rend / mf / (wr * factor)
d1 ( body ns ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( body nm ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d3 ( body nn ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d4 ( body nx ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d5 ( body ne ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rnwsti_m
 
// **********************************     N-well under STI resistor(Pure5V)   
//    ***********************************
subckt rnwsti_pure5v_m ( n1 n2 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.00438 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnwsti_pure5v_dis / 4 * (1 + factmis) dw=0.405e-6 - 0.05e-6 
+ pt=temp pvc1=4 * ((3.369e-08 / (max(wr * factor * 1e6,1.8)) + 8.881e-10) * (min(lr 
+ * factor * 1e6,100)) + ( - 1.492e-07 / (max(wr * factor * 1e6,1.8)) + 1.643e-07)) 
+ pvc2=0 ptc1=3.5e-03 ptc2=0.8e-05 ptc1_end=0 ptc2_end=-2e-5 tfacend=1.0 + ptc1_end 
+ * (pt - 25.0) + ptc2_end * (pt - 25.0) * (pt - 25.0) tfac=1.0 + ptc1 * (pt - 25.0) 
+ + ptc2 * (pt - 25.0) * (pt - 25.0) rmain=rsh / mf * lr * factor / (wr * factor 
+ - dw) * tfac rend=rend_rnwsti_pure5v_dis * (1 + factmis) 
rn1 ( n2 ns ) resistor r=rend / mf / (wr * factor) * tfacend
r1 ( ns nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(ns,nm)) / lr / factor) 
+ + pvc2 * (v(ns,nm) / lr / factor) * (v(ns,nm) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nm,nn)) / lr / factor) 
+ + pvc2 * (v(nm,nn) / lr / factor) * (v(nm,nn) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nn,nx)) / lr / factor) 
+ + pvc2 * (v(nn,nx) / lr / factor) * (v(nn,nx) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx ne ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nx,ne)) / lr / factor) 
+ + pvc2 * (v(nx,ne) / lr / factor) * (v(nx,ne) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
rn2 ( ne n1 ) resistor r=rend / mf / (wr * factor) * tfacend
d1 ( body ns ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( body nm ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d3 ( body nn ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d4 ( body nx ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d5 ( body ne ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rnwsti_pure5v_m
 
// **********************************     N-Well under OD resistor     ***********************************
subckt rnwod_m ( n1 n2 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.00382 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnwod_dis / 4 * (1 + factmis) dw=0.205u pt=temp pvc1=4 
+ * ((2.293e-08 / (max(wr * factor * 1e6,1.8)) + 1.259e-09) * (min(lr * factor * 
+ 1e6,100)) + ( - 5.381e-08 / (max(wr * factor * 1e6,1.8)) + 6.448e-08)) pvc2=0 
+ ptc1=2.658e-03 ptc2=8.126e-06 tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) 
+ * (pt - 25.0) rmain=rsh / mf * lr * factor / (wr * factor - dw) * tfac rend=rend_rnwod_dis 
+ * (1 + factmis) 
rn1 ( n2 ns ) resistor r=rend / mf / (wr * factor + 0.5u)
r1 ( ns nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(ns,nm)) / lr / factor) 
+ + pvc2 * (v(ns,nm) / lr / factor) * (v(ns,nm) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nm,nn)) / lr / factor) 
+ + pvc2 * (v(nm,nn) / lr / factor) * (v(nm,nn) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nn,nx)) / lr / factor) 
+ + pvc2 * (v(nn,nx) / lr / factor) * (v(nn,nx) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx ne ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nx,ne)) / lr / factor) 
+ + pvc2 * (v(nx,ne) / lr / factor) * (v(nx,ne) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
rn2 ( ne n1 ) resistor r=rend / mf / (wr * factor + 0.5u)
d1 ( body ns ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( body nm ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d3 ( body nn ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d4 ( body nx ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d5 ( body ne ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rnwod_m
 
// **********************************     N-Well under OD resistor (Pure5V)   
//   ***********************************
subckt rnwod_pure5v_m ( n1 n2 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=mismatchflag_disres geo_fac=1 
+ / sqrt(mf * lr * factor * wr * factor * 1e12) factmis=0.00406 * geo_fac * par_res_dis 
+ * mismatchflag rsh=r_rnwod_pure5v_dis / 4 * (1 + factmis) dw=0.205u pt=temp 
+ pvc1=4 * ((2.293e-08 / (max(wr * factor * 1e6,1.8)) + 1.259e-09) * (min(lr * factor 
+ * 1e6,100)) + ( - 5.381e-08 / (max(wr * factor * 1e6,1.8)) + 6.448e-08)) pvc2=0 
+ ptc1=2.61e-03 ptc2=8.2e-06 tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) 
+ * (pt - 25.0) rmain=rsh / mf * lr * factor / (wr * factor - dw) * tfac rend=rend_rnwod_pure5v_dis 
+ * (1 + factmis) 
rn1 ( n2 ns ) resistor r=rend / mf / (wr * factor + 0.5u)
r1 ( ns nm ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(ns,nm)) / lr / factor) 
+ + pvc2 * (v(n2,nm) / lr / factor) * (v(ns,nm) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r2 ( nm nn ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nm,nn)) / lr / factor) 
+ + pvc2 * (v(nm,nn) / lr / factor) * (v(nm,nn) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r3 ( nn nx ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nn,nx)) / lr / factor) 
+ + pvc2 * (v(nn,nx) / lr / factor) * (v(nn,nx) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
r4 ( nx ne ) resistor r=max(min(rmain * (1 + pvc1 * (abs(v(nx,ne)) / lr / factor) 
+ + pvc2 * (v(nx,ne) / lr / factor) * (v(nx,ne) / lr / factor)),rmain * 1.5),rmain 
+ / 2)
rn2 ( ne n1 ) resistor r=rend / mf / (wr * factor + 0.5u)
d1 ( body ns ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
d2 ( body nm ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d3 ( body nn ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d4 ( body nx ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * 2.0 * lr 
+ / 5.0
d5 ( body ne ) nwdio area=mf * ((wr - dw / factor) * lr / 5.0) pj=mf * ((wr - dw 
+ / factor) + 2.0 * lr / 5.0)
ends rnwod_pure5v_m
 
endsection disres
 
// *******************************************************
// ****** Baseband MOS Varactor Corner Parameters ********
// *******************************************************
 

section tt_bbmvar
parameters cmv_bb_cgmin=1.0
parameters cmv_bb_dcg=1.0
include "cmn018_gp2a_5v_v1d4.scs" section=bb_mvar
endsection tt_bbmvar
 

section ff_bbmvar
parameters cmv_bb_cgmin=0.92
parameters cmv_bb_dcg=0.9556
include "cmn018_gp2a_5v_v1d4.scs" section=bb_mvar
endsection ff_bbmvar
 

section ss_bbmvar
parameters cmv_bb_cgmin=1.08
parameters cmv_bb_dcg=1.0444
include "cmn018_gp2a_5v_v1d4.scs" section=bb_mvar
endsection ss_bbmvar
 

section mc_bbmvar
parameters par1_bbmvar=0
parameters par2_bbmvar=0
parameters a1_bbmvar=0.0267 * par1_bbmvar
parameters a2_bbmvar=0.0148 * par2_bbmvar
parameters cmv_bb_cgmin=1.0 + a1_bbmvar
parameters cmv_bb_dcg=1.0 + a2_bbmvar

statistics {
    process {
        vary par1_bbmvar dist=gauss std=1/1
        vary par2_bbmvar dist=gauss std=1/1
        }
    }
include "cmn018_gp2a_5v_v1d4.scs" section=bb_mvar
endsection mc_bbmvar
 

section bb_mvar
 
// *************************************************************************
//                                                                         *
//                  1.8V IO NMOS in N-Well varactor MODEL                  *
//                                                                         *
// *************************************************************************
subckt nmoscap ( ng nds ) 
parameters lr=1e-6 wr=1e-6 mr=1 factor=1 area=lr * factor * wr * factor * mr pj=2 
+ * wr * factor * mr dt=temp - 25 cgmin=(3.727e-10 * pj + 2.008e-03 * area) * 
+ (1 + 4.84e-5 * dt + 8.53e-7 * dt * dt) * cmv_bb_cgmin dcg=( - 2.42e-11 * pj + 
+ 3.298e-03 * area) * (1 - 8.303e-5 * dt - 2.889e-7 * dt * dt) * cmv_bb_dcg dvgs= 
+ - 0.08179 - 1.531e-04 * dt vgnorm=0.3939 + 5.273e-04 * dt 
cg ( ng nds ) bsource q=((cgmin+dcg)*v(ng,nds)+vgnorm*dcg*ln(cosh((v(ng,nds)-dvgs)/vgnorm)))
ends nmoscap
endsection bb_mvar
 
// **************************************************************
//                                                              *
//              LIB TT_BBMVAR5                                  *
//                  SS_BBMVAR5                                  *
//                  FF_BBMVAR5                                  *
//                                                              *
//              (   5V IO NMOS in N-Well varactor model )       *
